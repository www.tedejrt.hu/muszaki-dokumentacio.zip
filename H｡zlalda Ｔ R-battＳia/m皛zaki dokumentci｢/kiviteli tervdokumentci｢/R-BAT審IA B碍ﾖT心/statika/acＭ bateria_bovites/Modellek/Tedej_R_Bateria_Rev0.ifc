Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], ExchangeRequirement[Structural, SurfaceGeometry]
File name: Tedej_R_Bateria_Rev0.ifc
Time: 2018-01-23T05:51:00
Author: DESKTOP-9KMC89R\HGwor
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla Structures 21.0 Service Release 1, IFC Export Version: 4.0.0.0 Apr 27 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 2950*200 (5)
In: Undefined
Description: 2950*200; Material: CONCRETE/C25/30
Tekla Common - Bottom elevation: -0.000; Top elevation: +2.950; Phase: 1; Class: 1
Tekla Quantity - Height: 2950 mm; Width: 200 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) = NetWeight (kg) | Volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3)
BEAM | 12537.5 | 5 | 1.7 | 4.4 | 54.7 | 8500 | VB_Fal/2 | 54.73 | 5.015
2 x BEAM | 24190 | 9.7 | 3.3 | 4.3 | 104.5 | 16400 | VB_Fal/3 | 104.5 | 9.676
2 x BEAM | 15487.5 | 6.2 | 2.1 | 4.3 | 67.3 | 10500 | VB_Fal/1 | 67.33 | 6.195

# IfcBeam: L50*150*3 (4)
In: Undefined
Description: L50*150*3; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +2.950; Top elevation: +3.000; Phase: 1; Class: 95
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Height: 50 mm; Width: 150 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Profil | 15.2 | 1.3 | 3260 | B_FV/2 | 3260.02 | 1.30519 | 0.00192667 | 15.1244
2 x Profil | 22.1 | 1.9 | 4760 | B_FV/1 | 4760.01 | 1.90519 | 0.00281317 | 22.0834

# IfcBeam: L60*3 (4)
In: Undefined
Description: L60*3; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +3.081; Top elevation: +5.694; Phase: 2; Class: 13
Tekla Quantity - Weight: 24.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 2.1 m2; Height: 60 mm; Width: 60 mm; Length: 8741 mm
Pset_BeamCommon - LoadBearing: yes; Reference: B_S/6
BaseQuantities - Length: 8741 mm; OuterSurfaceArea: 2.09854 m2; NetVolume: 0.00306809 m3; NetWeight: 24.0845 kg

# IfcBeam: LH70/70/4 (2)
In: Undefined
Description: LH70/70/4; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +3.031; Top elevation: +5.437; Phase: 2; Class: 95
Tekla Quantity - Weight: 34.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 65.6 m2; Net surface area: 2.2 m2; Height: 70 mm; Width: 70 mm; Length: 8000 mm
Pset_BeamCommon - LoadBearing: yes; Reference: pfv/2
BaseQuantities - Length: 8000 mm; OuterSurfaceArea: 2.24109 m2; NetVolume: 0.004352 m3; NetWeight: 34.1632 kg

# IfcBeam: Z120/2.0_METAL (64)
In: Undefined
Description: Z120/2.0_METAL; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 128.6 m2; Net surface area: 1.4 m2; Height: 120 mm; Width: 86 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Szelemen | +5.522 | +5.662 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +5.522 | +5.662 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +5.522 | +5.662 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +5.127 | +5.267 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +5.127 | +5.267 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +5.127 | +5.267 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +4.739 | +4.879 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +4.739 | +4.879 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +4.739 | +4.879 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +4.350 | +4.490 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +4.350 | +4.490 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +4.350 | +4.490 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.976 | +4.115 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +3.976 | +4.115 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.976 | +4.115 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.572 | +3.712 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +3.572 | +3.712 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.572 | +3.712 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.183 | +3.323 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +3.183 | +3.323 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.183 | +3.323 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.008 | +3.148 | 10.8 | 3000 | B_S/3 | 1.39292 | 0.00138 | 10.833
4 x Szelemen | +3.008 | +3.148 | 11.6 | 3200 | B_S/5 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.008 | +3.148 | 11.6 | 3200 | B_S/4 | 1.48572 | 0.001472 | 11.5552
Szelemen | +5.522 | +5.662 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +5.522 | +5.662 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552
Szelemen | +5.127 | +5.267 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +5.127 | +5.267 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552
Szelemen | +4.739 | +4.879 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +4.739 | +4.879 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552
Szelemen | +4.350 | +4.490 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +4.350 | +4.490 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.976 | +4.115 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +3.976 | +4.115 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.572 | +3.712 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +3.572 | +3.712 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.183 | +3.323 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +3.183 | +3.323 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552
Szelemen | +3.008 | +3.148 | 10.8 | 3000 | B_S/2 | 1.39292 | 0.00138 | 10.833
Szelemen | +3.008 | +3.148 | 11.6 | 3200 | B_S/1 | 1.48572 | 0.001472 | 11.5552

# IfcBeam: ZáRT60/40/3 (48)
In: Undefined
Description: ZáRT60/40/3; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 4
Tekla Quantity - Volume: 0 m3; Area per tons: 44.8 m2; Height: 60 mm; Width: 40 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x Profil | +3.084 | +3.144 | 11.2 | 0.1 | 0.5 | 2524 | pm/4 | 0.50008 | 0.00142354 | 11.1748
4 x Profil | +5.364 | +5.424 | 11.2 | 0.1 | 0.5 | 2524 | pm/4 | 0.50008 | 0.00142354 | 11.1748
2 x Profil | +3.030 | +3.070 | 14.6 | 0.2 | 0.7 | 3330 | prt/44 | 0.651912 | 0.00185556 | 14.5661
6 x Profil | +2.970 | +3.030 | 11.2 | 0.1 | 0.5 | 2524 | pm/4 | 0.50008 | 0.00142354 | 11.1748
Profil | +2.970 | +3.030 | 10.8 | 0.1 | 0.5 | 2424 | pm/6 | 0.48029 | 0.00136713 | 10.732
3 x Profil | +3.934 | +4.003 | 10.8 | 0 | 0.5 | 2424 | pm/6 | 0.480291 | 0.00136714 | 10.732
3 x Profil | +4.973 | +5.042 | 10.8 | 0 | 0.5 | 2424 | pm/6 | 0.480291 | 0.00136714 | 10.732
2 x Profil | +4.973 | +5.042 | 10.3 | 0 | 0.5 | 2324 | pm/8 | 0.4605 | 0.00131073 | 10.2893
2 x Profil | +3.934 | +4.003 | 10.3 | 0 | 0.5 | 2324 | pm/8 | 0.4605 | 0.00131073 | 10.2893
6 x Profil | +2.975 | +3.045 | 10.6 | 0 | 0.5 | 2390 | pm/5 | 0.473562 | 0.00134796 | 10.5815
2 x Profil | +2.975 | +3.045 | 10.1 | 0 | 0.5 | 2290 | pm/7 | 0.453772 | 0.00129156 | 10.1387
Profil | +3.084 | +3.144 | 10.6 | 0.1 | 0.5 | 2424 | pm/6 | 0.48029 | 0.00136713 | 10.732
Profil | +5.364 | +5.424 | 10.6 | 0.1 | 0.5 | 2424 | pm/6 | 0.48029 | 0.00136713 | 10.732
3 x Profil | +4.184 | +4.244 | 11.2 | 0.1 | 0.5 | 2524 | pm/4 | 0.50008 | 0.00142354 | 11.1748
3 x Profil | +3.934 | +4.003 | 10.6 | 0 | 0.5 | 2424 | pm/6 | 0.480291 | 0.00136714 | 10.732
3 x Profil | +4.973 | +5.042 | 10.6 | 0 | 0.5 | 2424 | pm/6 | 0.480291 | 0.00136714 | 10.732
Profil | +4.184 | +4.244 | 10.6 | 0.1 | 0.5 | 2424 | pm/6 | 0.48029 | 0.00136713 | 10.732
Profil | +2.970 | +3.030 | 10.6 | 0.1 | 0.5 | 2424 | pm/6 | 0.48029 | 0.00136713 | 10.732

# IfcBeam: ZáRT60/60/3 (10)
In: Undefined
Description: ZáRT60/60/3; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +2.970; Top elevation: +3.030; Phase: 2; Class: 6
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.5 m2; Area per tons: 44.7 m2; Net surface area: 1.9 m2; Height: 60 mm; Width: 60 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Profil | 43.6 | 8213.2 | prt/24 | 8213.16 | 1.9492 | 0.00555068 | 43.5729
8 x Profil | 43.4 | 8173.2 | prt/23 | 8173.16 | 1.9396 | 0.00552332 | 43.3581

# IfcBeam: ZáRT80/60/3 (16)
In: Undefined
Description: ZáRT80/60/3; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.2 m2; Height: 80 mm; Width: 60 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x Profil | +3.013 | +3.965 | 24.1 | 1.1 | 3821.5 | pm/9 | 3821.55 | 1.06491 | 0.00307252 | 24.1193
2 x Profil | +3.974 | +5.002 | 25.4 | 1.1 | 4028.3 | pm/14 | 4028.28 | 1.12247 | 0.00323873 | 25.4241
2 x Profil | +4.994 | +5.513 | 17.8 | 0.7 | 2819.5 | pm/13 | 2819.53 | 0.785911 | 0.00226691 | 17.7952
2 x Profil | +4.994 | +5.512 | 17.2 | 0.7 | 2732.6 | pm/12 | 2732.6 | 0.761704 | 0.00219701 | 17.2465
2 x Profil | +3.014 | +3.964 | 23.7 | 0.9 | 3753.7 | pm/11 | 3753.73 | 1.04603 | 0.003018 | 23.6913
2 x Profil | +3.975 | +5.001 | 25 | 1.1 | 3963.5 | pm/10 | 3963.52 | 1.10444 | 0.00318667 | 25.0154

# IfcDiscreteAccessory: Lemez (510)
In: Undefined
Material: STEEL/S235JR
Tekla Common - Phase: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x Lemez | PL8*150 | +3.084 | +3.234 | 99 | 0.7 | 36.9 | 0 | 150 | 8 | 75 | pm/17 | 0.0261 | 0.0261 | 0.0012 | 0.00009 | 0.00009
8 x Lemez | PL8*150 | +3.039 | +3.189 | 99 | 0.4 | 39.9 | 0 | 150 | 8 | 40 | pm/16 | 0.01504 | 0.01504 | 0.0012 | 0.000048 | 0.000048
2 x Lemez | PL8*150 | +5.274 | +5.424 | 99 | 0.7 | 36.9 | 0 | 150 | 8 | 75 | pm/17 | 0.0261 | 0.0261 | 0.0012 | 0.00009 | 0.00009
8 x Lemez | PL8*150 | +5.319 | +5.469 | 99 | 0.4 | 39.9 | 0 | 150 | 8 | 40 | pm/16 | 0.01504 | 0.01504 | 0.0012 | 0.000048 | 0.000048
2 x Lemez | LV10*90 | +4.961 | +4.988 | 95 | 0.4 | 32.6 | 0 | 90 | 10 | 60 | pfv/1 | 0.0138 | 0.0138 | 0.0009 | 0.000054 | 0.000054
2 x Lemez | LV10*90 | +3.921 | +3.948 | 95 | 0.4 | 32.6 | 0 | 90 | 10 | 60 | pfv/1 | 0.0138 | 0.0138 | 0.0009 | 0.000054 | 0.000054
8 x Lemez | LV5*50 | +5.536 | +5.648 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +5.531 | +5.643 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +5.536 | +5.648 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
8 x Lemez | LV5*50 | +5.141 | +5.254 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +5.136 | +5.248 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +5.141 | +5.254 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
8 x Lemez | LV5*50 | +4.752 | +4.865 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +4.748 | +4.859 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +4.752 | +4.865 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
8 x Lemez | LV5*50 | +4.363 | +4.476 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +4.359 | +4.470 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +4.363 | +4.476 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
8 x Lemez | LV5*50 | +3.989 | +4.102 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +3.985 | +4.096 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +3.989 | +4.102 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
8 x Lemez | LV5*50 | +3.585 | +3.698 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +3.581 | +3.692 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +3.585 | +3.698 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
8 x Lemez | LV5*50 | +3.197 | +3.309 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +3.192 | +3.304 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +3.197 | +3.309 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
8 x Lemez | LV5*50 | +3.021 | +3.134 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100447 | 0.00575018 | 0.000025 | 0.0000213772 | 0.0000213772
10 x Lemez | LV5*90 | +3.017 | +3.128 | 3 | 0.4 | 56 | 0 | 90 | 5 | 115 | prt/2 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
2 x Lemez | LV5*50 | +3.021 | +3.134 | 1 | 0.2 | 59.9 | 0 | 50 | 5 | 115 | prt/1 | 0.0100443 | 0.00575012 | 0.000025 | 0.0000213761 | 0.0000213761
16 x Lemez | PL8*150 | +2.970 | +3.030 | 99 | 0.7 | 37.8 | 0 | 150 | 8 | 60 | pm/19 | 0.02136 | 0.02136 | 0.0012 | 0.000072 | 0.000072
6 x Lemez | PL8*70 | +3.824 | +4.021 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
6 x Lemez | PL8*70 | +3.826 | +4.022 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
6 x Lemez | PL8*70 | +2.958 | +3.154 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
6 x Lemez | PL8*70 | +2.956 | +3.152 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
16 x Lemez | PL8*50 | +3.889 | +4.047 | 99 | 0.4 | 38.6 | 0 | 50 | 8 | 150 | pm/15 | 0.0182 | 0.0182 | 0.0004 | 0.00006 | 0.00006
16 x Lemez | PL8*50 | +3.889 | +4.047 | 99 | 0.4 | 38.6 | 0 | 50 | 8 | 150 | prt/55 | 0.0182 | 0.0182 | 0.0004 | 0.00006 | 0.00006
16 x Lemez | PL8*50 | +4.929 | +5.087 | 99 | 0.4 | 38.6 | 0 | 50 | 8 | 150 | pm/15 | 0.0182 | 0.0182 | 0.0004 | 0.00006 | 0.00006
16 x Lemez | PL8*50 | +4.929 | +5.087 | 99 | 0.4 | 38.6 | 0 | 50 | 8 | 150 | prt/55 | 0.0182 | 0.0182 | 0.0004 | 0.00006 | 0.00006
2 x Lemez | PL8*70 | +5.368 | +5.568 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +5.369 | +5.569 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.938 | +5.139 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.937 | +5.138 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.862 | +5.057 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.863 | +5.059 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +3.919 | +4.114 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +3.917 | +4.113 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +5.367 | +5.567 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +5.368 | +5.569 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.939 | +5.139 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.938 | +5.138 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.861 | +5.056 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +4.862 | +5.058 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +2.959 | +3.155 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +2.957 | +3.153 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +3.823 | +4.019 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +3.825 | +4.021 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +3.918 | +4.114 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | prt/54 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
2 x Lemez | PL8*70 | +3.920 | +4.115 | 99 | 0.7 | 36.9 | 0 | 70 | 8 | 190 | pm/18 | 0.03076 | 0.03076 | 0.00056 | 0.0001064 | 0.0001064
16 x Lemez | PL5*60 | +2.973 | +3.047 | 99 | 0.2 | 58.6 | 0 | 60 | 5 | 75 | pm/2 | 0.01035 | 0.01035 | 0.0003 | 0.0000225 | 0.0000225
16 x Lemez | PL5*40 | +2.975 | +3.045 | 99 | 0.1 | 61.6 | 0 | 40 | 5 | 60 | pm/3 | 0.0058 | 0.0058 | 0.0002 | 0.000012 | 0.000012
16 x Lemez | PL5*60 | +2.970 | +3.045 | 99 | 0.2 | 58.5 | 0 | 60 | 5 | 77 | prt/16 | 0.01061 | 0.01061 | 0.0003 | 0.0000231 | 0.0000231
Lemez | PL8*150 | +4.139 | +4.289 | 99 | 0.7 | 36.9 | 0 | 150 | 8 | 75 | pm/17 | 0.0261 | 0.0261 | 0.0012 | 0.00009 | 0.00009
7 x Lemez | PL8*150 | +4.139 | +4.289 | 99 | 0.4 | 39.9 | 0 | 150 | 8 | 40 | pm/16 | 0.01504 | 0.01504 | 0.0012 | 0.000048 | 0.000048
4 x Lemez | LV2*80 | +2.958 | +2.960 | 251 | 0.2 | 133.9 | 0 | 80 | 2 | 145 | prt/21 | 0.0223608 | 0.0115984 | 0.000004 | 0.0000212771 | 0.0000329564
4 x Lemez | LV3*80 | +2.955 | +2.958 | 251 | 0.4 | 91.4 | 0 | 80 | 3 | 145 | prt/19 | 0.0229027 | 0.0115984 | 0.000009 | 0.0000319156 | 0.0000494345
4 x Lemez | LV10*80 | +2.950 | +2.960 | 251 | 0.7 | 32 | 0 | 80 | 10 | 145 | prt/12 | 0.0266957 | 0.0115984 | 0.0001 | 0.000106385 | 0.000164782
4 x Lemez | PL5*80 | +2.950 | +2.955 | 251 | 0.4 | 57.4 | 0 | 80 | 5 | 145 | prt/17 | 0.0239864 | 0.0115984 | 0.000025 | 0.0000531927 | 0.0000823909
2 x Lemez | LV10*160 | +2.960 | +2.970 | 21 | 0.9 | 30.4 | 0 | 80 | 10 | 145 | prt/14 | 0.0276972 | 0.0813932 | 0.0016 | 0.000115988 | 0.000367968
10 x Lemez | PL15*200 | +5.428 | +5.618 | 99 | 4.5 | 19.6 | 0.1 | 200 | 15 | 190 | prt/52 | 0.0876997 | 0.0876997 | 0.003 | 0.000569998 | 0.000569998
2 x Lemez | PL15*140 | +2.970 | +3.110 | 99 | 3.8 | 19.9 | 0.1 | 140 | 15 | 230 | prt/53 | 0.0755 | 0.0755 | 0.0021 | 0.000483 | 0.000483
10 x Lemez | LV5*60 | +2.970 | +3.015 | 7 | 0.1 | 60.9 | 0 | 60 | 5 | 44.9 | prt/3 | 0.006436 | 0.006436 | 0.0003 | 0.0000134677 | 0.0000134677
2 x Lemez | LV10*160 | +2.960 | +2.970 | 21 | 1.4 | 29.3 | 0 | 125 | 10 | 145 | prt/13 | 0.0416459 | 0.0813932 | 0.0016 | 0.000181231 | 0.000367968
2 x Lemez | LV2*80 | +2.958 | +2.960 | 251 | 0.2 | 133.9 | 0 | 80 | 2 | 145 | prt/21 | 0.0223627 | 0.0115993 | 0.000004 | 0.000021279 | 0.0000329564
2 x Lemez | LV3*80 | +2.955 | +2.958 | 251 | 0.4 | 91.4 | 0 | 80 | 3 | 145 | prt/19 | 0.0229046 | 0.0115993 | 0.000009 | 0.0000319185 | 0.0000494345
2 x Lemez | LV10*80 | +2.950 | +2.960 | 251 | 0.7 | 32 | 0 | 80 | 10 | 145 | prt/12 | 0.0266977 | 0.0115993 | 0.0001 | 0.000106395 | 0.000164782
2 x Lemez | PL5*80 | +2.950 | +2.955 | 251 | 0.4 | 57.4 | 0 | 80 | 5 | 145 | prt/17 | 0.0239883 | 0.0115993 | 0.000025 | 0.0000531975 | 0.0000823909
2 x Lemez | LV10*160 | +2.960 | +2.970 | 21 | 1.4 | 29.3 | 0 | 125 | 10 | 145 | prt/13 | 0.0416487 | 0.0813932 | 0.0016 | 0.000181244 | 0.000367968
6 x Lemez | LV10*160 | +2.840 | +2.950 | 7 | 1.4 | 29.4 | 0 | 160 | 10 | 110 | prt/11 | 0.0406 | 0.0406 | 0.0016 | 0.000176 | 0.000176
6 x Lemez | LV5*140 | +2.950 | +2.955 | 7 | 0.4 | 57.9 | 0 | 140 | 5 | 50 | prt/6 | 0.0159 | 0.0159 | 0.0007 | 0.000035 | 0.000035
6 x Lemez | LV5*120 | +2.955 | +2.960 | 7 | 0.2 | 58.7 | 0 | 120 | 5 | 44.9 | prt/5 | 0.01245 | 0.01245 | 0.0006 | 0.000027 | 0.000027
6 x Lemez | LV8*50 | +2.850 | +2.960 | 1050 | 0.4 | 40.8 | 0 | 50 | 8 | 110 | prt/22 | 0.0105147 | 0.0055015 | 0.000064 | 0.0000328084 | 0.0000328084
6 x Lemez | LV10*160 | +2.840 | +2.960 | 7 | 1.4 | 29.3 | 0 | 160 | 10 | 120 | prt/10 | 0.0440102 | 0.0440102 | 0.0016 | 0.000192048 | 0.000192048
6 x Lemez | LV10*100 | +2.960 | +2.970 | 7 | 0.9 | 30.1 | 0 | 100 | 10 | 120 | prt/9 | 0.0284 | 0.0284 | 0.001 | 0.00012 | 0.00012
8 x Lemez | LV5*60 | +2.970 | +3.030 | 7 | 0.1 | 59.4 | 0 | 60 | 5 | 60 | prt/4 | 0.0084 | 0.0084 | 0.0003 | 0.000018 | 0.000018
6 x Lemez | LV2*80 | +2.958 | +2.960 | 251 | 0.4 | 133.6 | 0 | 80 | 2 | 230 | prt/20 | 0.0345638 | 0.0183979 | 0.000004 | 0.0000329564 | 0.0000329564
6 x Lemez | LV3*80 | +2.955 | +2.958 | 251 | 0.4 | 91.1 | 0 | 80 | 3 | 230 | prt/18 | 0.0353675 | 0.0183979 | 0.000009 | 0.0000494345 | 0.0000494345
6 x Lemez | LV10*80 | +2.950 | +2.960 | 251 | 1.3 | 31.7 | 0 | 80 | 10 | 230 | prt/8 | 0.0409937 | 0.0183979 | 0.0001 | 0.000164782 | 0.000164782
6 x Lemez | PL5*80 | +2.950 | +2.955 | 251 | 0.7 | 57.2 | 0 | 80 | 5 | 230 | prt/15 | 0.036975 | 0.0183979 | 0.000025 | 0.0000823909 | 0.0000823909
6 x Lemez | LV10*160 | +2.960 | +2.970 | 21 | 2.3 | 28.6 | 0.1 | 125 | 10 | 230 | prt/7 | 0.0645946 | 0.0813932 | 0.0016 | 0.000287475 | 0.000367968

# IfcDiscreteAccessory: Profil (180)
In: Undefined
Material: STEEL/S235JR
Tekla Common - Phase: 2
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x Profil | ZáRT70/70/3 | +4.215 | +4.285 | 95 | 21 | 0.2 | 44.4 | 0.9 | 70 | 70 | 3325 | prt/59 | 0.931839 | 0.931839 | 0.00077866 | 0.0026733 | 0.0026733
2 x Profil | ZáRT60/40/3 | +3.030 | +5.458 | 4 | 10.5 | 0 | 44.8 | 0.5 | 60 | 40 | 2428.1 | prt/40 | 0.472117 | 0.472117 | 0.00053866 | 0.00134292 | 0.00134292
2 x Profil | ZáRT60/40/3 | +4.410 | +5.458 | 4 | 15.2 | 0 | 44.8 | 0.7 | 60 | 40 | 3482.1 | prt/41 | 0.68169 | 0.68169 | 0.00053866 | 0.00194034 | 0.00194034
2 x Profil | ZáRT60/40/3 | +3.030 | +4.440 | 4 | 6.1 | 0 | 44.8 | 0.3 | 60 | 40 | 1410 | prt/42 | 0.272934 | 0.272934 | 0.00053866 | 0.000775614 | 0.000775614
2 x Profil | ZáRT60/40/3 | +3.070 | +4.930 | 4 | 8.2 | 0 | 44.8 | 0.3 | 60 | 40 | 1860.1 | prt/43 | 0.36751 | 0.36751 | 0.00053866 | 0.00104567 | 0.00104567
2 x Profil | LH70/70/4 | +3.050 | +5.547 | 95 | 35.5 | 0 | 65.6 | 2.3 | 70 | 70 | 8312.4 | prt/56 | 2.32856 | 2.32856 | 0.000559017 | 0.00452195 | 0.00452195
2 x Profil | ZáRT70/70/3 | +4.215 | +4.285 | 95 | 21.3 | 0.2 | 44.4 | 0.9 | 70 | 70 | 3370 | prt/58 | 0.94444 | 0.94444 | 0.00077866 | 0.00270948 | 0.00270948
2 x Profil | LH70/70/4 | +2.970 | +3.040 | 95 | 34.8 | 0 | 65.6 | 2.3 | 70 | 70 | 8144.7 | prt/57 | 2.2816 | 2.2816 | 0.000559017 | 0.00443072 | 0.00443072
6 x Profil | ZáRT80/60/3 | +2.983 | +3.097 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 115.3 | prt/45 | 0.0229801 | 0.0229801 | 0.00077866 | 0.0000632448 | 0.0000632448
6 x Profil | ZáRT80/60/3 | +3.881 | +3.995 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 115.3 | prt/45 | 0.0229802 | 0.0229802 | 0.00077866 | 0.0000632448 | 0.0000632448
16 x Profil | ZáRT60/40/3 | +3.934 | +4.003 | 4 | 0.2 | 0 | 47.9 | 0 | 60 | 40 | 42 | prt/29 | 0.00890526 | 0.00890526 | 0.00053866 | 0.000023688 | 0.000023688
16 x Profil | ZáRT60/40/3 | +4.973 | +5.042 | 4 | 0.2 | 0 | 47.9 | 0 | 60 | 40 | 42 | prt/29 | 0.00890526 | 0.00890526 | 0.00053866 | 0.000023688 | 0.000023688
2 x Profil | ZáRT80/60/3 | +5.424 | +5.527 | 3 | 0.4 | 0 | 46.5 | 0 | 80 | 60 | 78.5 | prt/49 | 0.0176944 | 0.0176944 | 0.00077866 | 0.0000484753 | 0.0000484753
2 x Profil | ZáRT80/60/3 | +4.919 | +5.034 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 122 | prt/50 | 0.0239741 | 0.0239741 | 0.00077866 | 0.0000660133 | 0.0000660133
2 x Profil | ZáRT80/60/3 | +5.423 | +5.527 | 3 | 0.4 | 0 | 46.5 | 0 | 80 | 60 | 79.9 | prt/46 | 0.0178848 | 0.0178848 | 0.00077866 | 0.0000490099 | 0.0000490099
2 x Profil | ZáRT80/60/3 | +4.918 | +5.034 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 124.9 | prt/47 | 0.02437 | 0.02437 | 0.00077866 | 0.0000671051 | 0.0000671051
2 x Profil | ZáRT80/60/3 | +3.880 | +3.995 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 118.3 | prt/48 | 0.0234044 | 0.0234044 | 0.00077866 | 0.0000644239 | 0.0000644239
2 x Profil | ZáRT80/60/3 | +3.942 | +4.057 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 122 | prt/50 | 0.0239741 | 0.0239741 | 0.00077866 | 0.0000660133 | 0.0000660133
2 x Profil | ZáRT80/60/3 | +4.979 | +5.083 | 3 | 0.4 | 0 | 46.5 | 0 | 80 | 60 | 78.5 | prt/49 | 0.0176944 | 0.0176944 | 0.00077866 | 0.0000484753 | 0.0000484753
2 x Profil | ZáRT80/60/3 | +2.983 | +3.098 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 118.3 | prt/48 | 0.0234044 | 0.0234044 | 0.00077866 | 0.0000644239 | 0.0000644239
2 x Profil | ZáRT80/60/3 | +3.942 | +4.058 | 3 | 0.4 | 0 | 46.3 | 0 | 80 | 60 | 124.9 | prt/47 | 0.0243948 | 0.0243948 | 0.00077866 | 0.0000671767 | 0.0000671767
2 x Profil | ZáRT80/60/3 | +4.979 | +5.083 | 3 | 0.4 | 0 | 46.5 | 0 | 80 | 60 | 79.7 | prt/46 | 0.0178369 | 0.0178369 | 0.00077866 | 0.0000488713 | 0.0000488713
Profil | ZáRT60/40/3 | +3.030 | +5.481 | 4 | 10.8 | 0 | 44.8 | 0.5 | 60 | 40 | 2451 | prt/28 | 0.48444 | 0.48444 | 0.00053866 | 0.00137892 | 0.00137892
10 x Profil | ZáRT60/40/3 | +3.030 | +3.413 | 4 | 1.7 | 0 | 45.1 | 0.1 | 60 | 40 | 382.7 | prt/30 | 0.0751408 | 0.0751408 | 0.00053866 | 0.000212421 | 0.000212421
10 x Profil | ZáRT60/40/3 | +3.030 | +3.933 | 4 | 4 | 0 | 44.9 | 0.2 | 60 | 40 | 902.5 | prt/31 | 0.177995 | 0.177995 | 0.00053866 | 0.000505555 | 0.000505555
10 x Profil | ZáRT60/40/3 | +3.030 | +4.452 | 4 | 6.3 | 0 | 44.8 | 0.3 | 60 | 40 | 1422.2 | prt/32 | 0.280849 | 0.280849 | 0.00053866 | 0.000798689 | 0.000798689
10 x Profil | ZáRT80/60/3 | +2.970 | +5.565 | 3 | 54.8 | 0 | 44.1 | 2.4 | 80 | 60 | 8734.2 | prt/51 | 2.41738 | 2.42917 | 0.00077866 | 0.00697635 | 0.00701171
10 x Profil | ZáRT60/40/3 | +3.030 | +4.972 | 4 | 8.6 | 0 | 44.8 | 0.3 | 60 | 40 | 1942 | prt/33 | 0.383703 | 0.383703 | 0.00053866 | 0.00109182 | 0.00109182
2 x Profil | ZáRT60/40/3 | +3.030 | +4.992 | 4 | 11 | 0 | 44.8 | 0.5 | 60 | 40 | 2523 | prt/39 | 0.492978 | 0.492978 | 0.00053866 | 0.001403 | 0.001403
10 x Profil | ZáRT60/40/3 | +3.030 | +4.956 | 4 | 10.8 | 0 | 44.8 | 0.5 | 60 | 40 | 2530.4 | prt/35 | 0.488016 | 0.488016 | 0.00053866 | 0.00138824 | 0.00138824
10 x Profil | ZáRT60/40/3 | +3.030 | +3.958 | 4 | 7.9 | 0 | 44.8 | 0.3 | 60 | 40 | 1873.2 | prt/36 | 0.356274 | 0.356274 | 0.00053866 | 0.00101258 | 0.00101258
10 x Profil | ZáRT60/40/3 | +3.030 | +3.919 | 4 | 7.5 | 0 | 44.9 | 0.3 | 60 | 40 | 1866.5 | prt/37 | 0.335871 | 0.335871 | 0.00053866 | 0.000951863 | 0.000951863
Profil | ZáRT60/40/3 | +3.030 | +5.481 | 4 | 10.8 | 0 | 44.8 | 0.5 | 60 | 40 | 2451 | prt/26 | 0.48444 | 0.48444 | 0.00053866 | 0.00137892 | 0.00137892
Profil | ZáRT60/40/3 | +3.030 | +5.470 | 4 | 10.8 | 0 | 44.8 | 0.5 | 60 | 40 | 2440.3 | prt/27 | 0.482323 | 0.482323 | 0.00053866 | 0.00137289 | 0.00137289
8 x Profil | ZáRT60/40/3 | +3.030 | +4.992 | 4 | 10.8 | 0 | 44.8 | 0.5 | 60 | 40 | 2501 | prt/34 | 0.48881 | 0.48881 | 0.00053866 | 0.00139114 | 0.00139114
4 x Profil | ZáRT60/40/3 | +3.030 | +5.470 | 4 | 10.8 | 0 | 44.8 | 0.5 | 60 | 40 | 2440.3 | prt/25 | 0.482323 | 0.482323 | 0.00053866 | 0.00137289 | 0.00137289
3 x Profil | ZáRT60/40/3 | +3.030 | +5.470 | 4 | 10.8 | 0 | 44.8 | 0.5 | 60 | 40 | 2440.3 | prt/38 | 0.482323 | 0.482323 | 0.00053866 | 0.00137289 | 0.00137289

# IfcElementAssembly (153)
In: Undefined
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
2 x Steel Assembly | RIGID_FRAME | 24.1 | +3.081 | +5.694 | 22/B-A | B_S/6 | 60
Steel Assembly | RIGID_FRAME | 12.3 | +3.039 | +3.234 | 22-23/B-A | B_M/8 | 75
Steel Assembly | RIGID_FRAME | 12.3 | +5.274 | +5.469 | 22-23/B-A | B_M/9 | 75
Steel Assembly | RIGID_FRAME | 75.6 | +3.030 | +5.458 | 22-23/B-A | B_RT/12 | 2428.08
Steel Assembly | RIGID_FRAME | 75.6 | +3.030 | +5.458 | 22-23/B-A | B_RT/11 | 2428.08
2 x Steel Assembly | RIGID_FRAME | 15.1 | +2.950 | +3.000 | 22-23/B-A | B_FV/2 | 150
2 x Steel Assembly | RIGID_FRAME | 22.1 | +2.950 | +3.000 | 22-23/B-A | B_FV/1 | 150
Steel Assembly | RIGID_FRAME | 35 | +3.031 | +5.437 | 22-23/B-A | B_FV/4 | 80
Steel Assembly | RIGID_FRAME | 35 | +3.031 | +5.437 | 22-23/B-A | B_FV/3 | 80
2 x Steel Assembly | RIGID_FRAME | 24.1 | +3.081 | +5.694 | 26/B-A | B_S/6 | 60
Steel Assembly | RIGID_FRAME | 278.6 | +2.950 | +5.648 | 26/B-A | B_RT/1 | 214.989
Steel Assembly | RIGID_FRAME | 278.6 | +2.950 | +5.648 | 26/B-A | B_RT/8 | 214.996
Steel Assembly | RIGID_FRAME | 10.8 | +5.522 | +5.662 | 22-23/B-A | B_S/3 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +5.522 | +5.662 | 23-24/B-A | B_S/5 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +5.522 | +5.662 | 24-25/B-A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +5.522 | +5.662 | 25-26/B-A | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +5.127 | +5.267 | 22-23/B-A | B_S/3 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +5.127 | +5.267 | 23-24/B-A | B_S/5 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +5.127 | +5.267 | 24-25/B-A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +5.127 | +5.267 | 25-26/B-A | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +4.739 | +4.879 | 22-23/B-A | B_S/3 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +4.739 | +4.879 | 23-24/B-A | B_S/5 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +4.739 | +4.879 | 24-25/B-A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +4.739 | +4.879 | 25-26/B-A | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +4.350 | +4.490 | 22-23/B-A | B_S/3 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +4.350 | +4.490 | 23-24/B-A | B_S/5 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +4.350 | +4.490 | 24-25/B-A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +4.350 | +4.490 | 25-26/B-A | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.976 | +4.115 | 22-23/B-A | B_S/3 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.976 | +4.115 | 23-24/B-A | B_S/5 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.976 | +4.115 | 24-25/B-A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.976 | +4.115 | 25-26/B-A | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.572 | +3.712 | 22-23/B-A | B_S/3 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.572 | +3.712 | 23-24/B-A | B_S/5 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.572 | +3.712 | 24-25/B-A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.572 | +3.712 | 25-26/B-A | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.183 | +3.323 | 22-23/B-A | B_S/3 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.183 | +3.323 | 23-24/B-A | B_S/5 | 86
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.183 | +3.323 | 24-25/B-A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.183 | +3.323 | 25-26/B-A | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.008 | +3.148 | 22-23/B | B_S/3 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.008 | +3.148 | 23-24/B | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.008 | +3.148 | 24-25/B | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.008 | +3.148 | 25-26/B | B_S/4 | 86
Steel Assembly | RIGID_FRAME | 188.4 | +2.950 | +5.648 | 22/B-A | B_RT/10 | 230
Steel Assembly | RIGID_FRAME | 193.6 | +2.840 | +5.648 | 23/B-A | B_RT/7 | 229.981
Steel Assembly | RIGID_FRAME | 191 | +2.840 | +5.648 | 24/B-A | B_RT/2 | 229.981
Steel Assembly | RIGID_FRAME | 193.6 | +2.840 | +5.648 | 25/B-A | B_RT/3 | 229.981
Steel Assembly | RIGID_FRAME | 10.8 | +5.522 | +5.662 | 22-23/B-A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +5.522 | +5.662 | 25-26/B-A | B_S/1 | 86
Steel Assembly | RIGID_FRAME | 188.4 | +2.950 | +5.648 | 22/B-A | B_RT/9 | 230
Steel Assembly | RIGID_FRAME | 193.6 | +2.840 | +5.648 | 23/B-A | B_RT/4 | 229.981
Steel Assembly | RIGID_FRAME | 191 | +2.840 | +5.648 | 24/B-A | B_RT/5 | 229.981
Steel Assembly | RIGID_FRAME | 193.6 | +2.840 | +5.648 | 25/B-A | B_RT/6 | 229.981
Steel Assembly | RIGID_FRAME | 10.8 | +5.127 | +5.267 | 22-23/B-A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +5.127 | +5.267 | 25-26/B-A | B_S/1 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +4.739 | +4.879 | 22-23/B-A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +4.739 | +4.879 | 25-26/B-A | B_S/1 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +4.350 | +4.490 | 22-23/B-A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +4.350 | +4.490 | 25-26/B-A | B_S/1 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.976 | +4.115 | 22-23/B-A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.976 | +4.115 | 25-26/B-A | B_S/1 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.572 | +3.712 | 22-23/B-A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.572 | +3.712 | 25-26/B-A | B_S/1 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.183 | +3.323 | 22-23/B-A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.183 | +3.323 | 25-26/B-A | B_S/1 | 86
2 x Steel Assembly | RIGID_FRAME | 11.9 | +2.970 | +3.030 | 25-26/B-A | B_M/3 | 150
2 x Steel Assembly | RIGID_FRAME | 12.3 | +2.970 | +3.030 | 22-23/B-A | B_M/2 | 150
2 x Steel Assembly | RIGID_FRAME | 12.3 | +2.970 | +3.030 | 23-24/B-A | B_M/2 | 150
2 x Steel Assembly | RIGID_FRAME | 12.3 | +2.970 | +3.030 | 24-25/B-A | B_M/2 | 150
Steel Assembly | RIGID_FRAME | 25.8 | +2.958 | +4.021 | 23-24/B-A | B_M/11 | 70
2 x Steel Assembly | RIGID_FRAME | 25.8 | +2.958 | +4.021 | 22-23/B-A | B_M/11 | 70
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.889 | +4.047 | 22-23/B-A | B_M/12 | 50
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.889 | +4.047 | 23-24/B-A | B_M/12 | 50
2 x Steel Assembly | RIGID_FRAME | 11.6 | +4.929 | +5.087 | 22-23/B-A | B_M/12 | 50
2 x Steel Assembly | RIGID_FRAME | 11.6 | +4.929 | +5.087 | 23-24/B-A | B_M/12 | 50
2 x Steel Assembly | RIGID_FRAME | 11.6 | +4.929 | +5.087 | 24-25/B-A | B_M/12 | 50
2 x Steel Assembly | RIGID_FRAME | 11.6 | +3.889 | +4.047 | 24-25/B-A | B_M/12 | 50
2 x Steel Assembly | RIGID_FRAME | 11.2 | +3.889 | +4.047 | 25-26/B-A | B_M/13 | 50
2 x Steel Assembly | RIGID_FRAME | 11.2 | +4.929 | +5.087 | 25-26/B-A | B_M/13 | 50
2 x Steel Assembly | RIGID_FRAME | 19.5 | +4.938 | +5.568 | 22-23/B-A | B_M/18 | 70
Steel Assembly | RIGID_FRAME | 27.1 | +3.919 | +5.057 | 22-23/B-A | B_M/15 | 70.0001
2 x Steel Assembly | RIGID_FRAME | 25.8 | +2.958 | +4.021 | 24-25/B-A | B_M/11 | 70
2 x Steel Assembly | RIGID_FRAME | 18.9 | +4.939 | +5.567 | 25-26/B-A | B_M/17 | 70
2 x Steel Assembly | RIGID_FRAME | 26.7 | +3.920 | +5.056 | 25-26/B-A | B_M/16 | 70
2 x Steel Assembly | RIGID_FRAME | 25.4 | +2.959 | +4.019 | 25-26/B-A | B_M/10 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +2.973 | +3.047 | 25-26/B | B_M/5 | 40
Steel Assembly | RIGID_FRAME | 11.2 | +2.973 | +3.047 | 24-25/B | B_M/4 | 40
Steel Assembly | RIGID_FRAME | 11.2 | +2.973 | +3.047 | 23-24/B | B_M/4 | 40
Steel Assembly | RIGID_FRAME | 11.2 | +2.973 | +3.047 | 22-23/B | B_M/4 | 40
Steel Assembly | RIGID_FRAME | 12.3 | +3.039 | +3.234 | 22-23/B-A | B_M/9 | 75
Steel Assembly | RIGID_FRAME | 11.5 | +3.039 | +3.189 | 25-26/B-A | B_M/7 | 40
Steel Assembly | RIGID_FRAME | 11.9 | +3.039 | +3.189 | 23-24/B-A | B_M/6 | 40
Steel Assembly | RIGID_FRAME | 11.9 | +3.039 | +3.189 | 24-25/B-A | B_M/6 | 40
Steel Assembly | RIGID_FRAME | 12.3 | +5.274 | +5.469 | 22-23/B-A | B_M/8 | 75
Steel Assembly | RIGID_FRAME | 11.5 | +5.319 | +5.469 | 25-26/B-A | B_M/7 | 40
Steel Assembly | RIGID_FRAME | 11.9 | +5.319 | +5.469 | 23-24/B-A | B_M/6 | 40
Steel Assembly | RIGID_FRAME | 11.9 | +5.319 | +5.469 | 24-25/B-A | B_M/6 | 40
Steel Assembly | RIGID_FRAME | 12.3 | +4.139 | +4.289 | 22-23/B-A | B_M/14 | 75
Steel Assembly | RIGID_FRAME | 11.9 | +4.139 | +4.289 | 23-24/B-A | B_M/6 | 40
Steel Assembly | RIGID_FRAME | 11.9 | +4.139 | +4.289 | 24-25/B-A | B_M/6 | 40
Steel Assembly | RIGID_FRAME | 11.5 | +4.139 | +4.289 | 25-26/B-A | B_M/7 | 40
Steel Assembly | RIGID_FRAME | 25.8 | +2.958 | +4.021 | 23-24/B-A | B_M/11 | 70.0001
Steel Assembly | RIGID_FRAME | 27.1 | +3.919 | +5.057 | 22-23/B-A | B_M/15 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +2.973 | +3.047 | 25-26/A | B_M/5 | 40
Steel Assembly | RIGID_FRAME | 11.2 | +2.973 | +3.047 | 24-25/A | B_M/4 | 40
Steel Assembly | RIGID_FRAME | 11.2 | +2.973 | +3.047 | 23-24/A | B_M/4 | 40
Steel Assembly | RIGID_FRAME | 11.2 | +2.973 | +3.047 | 22-23/A | B_M/4 | 40
Steel Assembly | RIGID_FRAME | 11.6 | +3.008 | +3.148 | 23-24/A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 10.8 | +3.008 | +3.148 | 22-23/A | B_S/2 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.008 | +3.148 | 24-25/A | B_S/5 | 86
Steel Assembly | RIGID_FRAME | 11.6 | +3.008 | +3.148 | 25-26/A | B_S/1 | 86
BEAM | REINFORCEMENT_UNIT | 12537.5 | -0.000 | +2.950 | 22-26/B-A | VB_Fal/2 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
BEAM | REINFORCEMENT_UNIT | 24190 | -0.000 | +2.950 | 22-23/B-A | VB_Fal/3 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
BEAM | REINFORCEMENT_UNIT | 24190 | -0.000 | +2.950 | 26/B-A | VB_Fal/3 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
BEAM | REINFORCEMENT_UNIT | 15487.5 | -0.000 | +2.950 | 22-26/A | VB_Fal/1 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
BEAM | REINFORCEMENT_UNIT | 15487.5 | -0.000 | +2.950 | 22-26/B | VB_Fal/1 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg

# IfcMechanicalFastener: Bolt assembly (319)
In: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Slotted hole x: 0 mm
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Bolt hole diameter (mm) | Location | Bolt count | Bolt standard | Bolt Name
10 x Bolt assembly | 12 | 90 | 8.8 | 4 | 125 | SCHEIBE12-125 | 2 | 934 | MUN12-934 | 14 | Site | 2 | 931 | M12*90
2 x Bolt assembly | 10 | 18 | 5.8 | 12 | HILTI_125 | HILTI_SCHEIBE10-125 | 12 | HILTI_934 | HILTI_MU10-934 | 12 | Site | 6 | HSA | HSA M10X83 20/10/
2 x Bolt assembly | 10 | 18 | 5.8 | 18 | HILTI_125 | HILTI_SCHEIBE10-125 | 18 | HILTI_934 | HILTI_MU10-934 | 12 | Site | 9 | HSA | HSA M10X83 20/10/
80 x Bolt assembly | 12 | 28 | 8.8 | 8 | 126 | SCHEIBE12-126 | 4 | 934 | MUN12-934 | 14 | Site | 4 | 933 | M12*28
96 x Bolt assembly | 12 | 22 | 8.8 | 4 | 126 | SCHEIBE12-126 | 2 | 934 | MUN12-934 | 14 | Site | 2 | 933 | M12*22
3 x Bolt assembly | 16 | 90 | 8.8 | 4 | 125 | SCHEIBE16-125 | 2 | 934 | MUN16-934 | 18 | Site | 2 | 931 | M16*90
7 x Bolt assembly | 16 | 100 | 8.8 | 4 | 125 | SCHEIBE16-125 | 2 | 934 | MUN16-934 | 18 | Site | 2 | 931 | M16*100
32 x Bolt assembly | 16 | 55 | 8.8 | 4 | 125 | SCHEIBE16-125 | 2 | 934 | MUN16-934 | 18 | Site | 2 | 931 | M16*55
32 x Bolt assembly | 12 | 40 | 8.8 | 4 | 125 | SCHEIBE12-125 | 2 | 934 | MUN12-934 | 14 | Site | 2 | 931 | M12*40
16 x Bolt assembly | 12 | 28 | 8.8 | 4 | 126 | SCHEIBE12-126 | 2 | 934 | MUN12-934 | 14 | Site | 2 | 933 | M12*28
9 x Bolt assembly | 12 | 100 | 8.8 | 4 | 125 | SCHEIBE12-125 | 2 | 934 | MUN12-934 | 14 | Site | 2 | 931 | M12*100
18 x Bolt assembly | 16 | 45 | A4 (SS316) | 2 | HILTI_125 | HILTI_SCHEIBE16-125 | 1 | HILTI_934 | HILTI_MU16-934 | 20 | Site | 1 | HST-R | HST M16X165/50
5 x Bolt assembly | 20 | 65 | 8.8 | 12 | 125 | SCHEIBE20-125 | 6 | 934 | MUN20-934 | 22 | Site | 6 | 931 | M20*65
Bolt assembly | 20 | 65 | 8.8 | 8 | 125 | SCHEIBE20-125 | 4 | 934 | MUN20-934 | 22 | Site | 4 | 931 | M20*65
6 x Bolt assembly | 12 | 50 | A4 (SS316) | 4 | HILTI_125 | HILTI_SCHEIBE12-125 | 2 | HILTI_934 | HILTI_MU12-934 | 16 | Workshop | 2 | HST-R | HST M12X145/50
