Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcElementAssembly (923)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 1-4/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 2-5/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 3-6/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 4-7/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 5-8/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 6-9/C-B | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.313 | +7.537 | 11-13/C-B | S/7 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 10-13/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 7-10/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 9-12/C-B | S/5 | 138
2 x Steel Assembly | RIGID_FRAME | 38.6 | +7.313 | +7.537 | 8-11/C-B | S/5 | 138
Steel Assembly | RIGID_FRAME | 499.7 | +2.960 | +4.961 | 1/B-A | RT/14 | 355
Steel Assembly | RIGID_FRAME | 511.6 | +3.395 | +7.510 | 2/C-A | RT/19 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 3/C-A | RT/20 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 4/C-A | RT/20 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 5/C-A | RT/20 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 6/C-A | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 7/C-A | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 8/C-A | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 511.6 | +3.395 | +7.510 | 12/C-A | RT/24 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 11/C-A | RT/26 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 10/C-A | RT/26 | 489.994
Steel Assembly | RIGID_FRAME | 510.3 | +3.395 | +7.510 | 1/C-A | RT/21 | 400.001
Steel Assembly | RIGID_FRAME | 510.3 | +3.395 | +7.510 | 13/C-A | RT/28 | 399.993
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 9/C-A | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 36.5 | +3.529 | +3.753 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +3.529 | +3.753 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 499.7 | +2.960 | +4.961 | 13/D-C | RT/15 | 355
Steel Assembly | RIGID_FRAME | 36.5 | +3.820 | +4.044 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +3.820 | +4.044 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.111 | +4.335 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.111 | +4.335 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.402 | +4.626 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.402 | +4.626 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.693 | +4.917 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.693 | +4.917 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.984 | +5.208 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.984 | +5.208 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 511.6 | +3.395 | +7.510 | 12/D-B | RT/23 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 11/D-B | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 10/D-B | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 9/D-B | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 8/D-B | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 7/D-B | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 6/D-B | RT/25 | 489.994
Steel Assembly | RIGID_FRAME | 511.6 | +3.395 | +7.510 | 2/D-B | RT/18 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 3/D-B | RT/20 | 489.994
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 4/D-B | RT/20 | 489.994
Steel Assembly | RIGID_FRAME | 510.3 | +3.395 | +7.510 | 13/D-B | RT/27 | 400.001
Steel Assembly | RIGID_FRAME | 510.3 | +3.395 | +7.510 | 1/D-B | RT/22 | 399.993
Steel Assembly | RIGID_FRAME | 509.2 | +3.395 | +7.510 | 5/D-B | RT/20 | 489.994
Steel Assembly | RIGID_FRAME | 36.5 | +5.275 | +5.500 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.275 | +5.500 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.566 | +5.791 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.566 | +5.791 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.857 | +6.082 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.857 | +6.082 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.148 | +6.373 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.148 | +6.373 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.440 | +6.664 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.440 | +6.664 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.731 | +6.955 | 11-13/D-C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 10-13/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 9-12/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 8-11/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 7-10/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 6-9/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 5-8/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.731 | +6.955 | 1-3/D-C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 1-4/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 4-7/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 2-5/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 3-6/D-C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.022 | +7.246 | 11-13/C | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 10-13/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 9-12/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 8-11/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 7-10/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 6-9/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 5-8/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.022 | +7.246 | 1-3/C | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 1-4/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 4-7/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 2-5/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 3-6/C | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.313 | +7.537 | 1-3/C-B | S/7 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.313 | +7.537 | 11-13/C-B | S/6 | 138
Steel Assembly | RIGID_FRAME | 72.9 | +4.942 | +5.240 | 1-2/B-A | M/16 | 352.728
Steel Assembly | RIGID_FRAME | 72.9 | +3.970 | +4.268 | 1-2/B-A | M/11 | 351.792
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 11-12/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 10-11/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 9-10/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 8-9/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 7-8/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 6-7/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 5-6/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 4-5/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 49.8 | +3.108 | +4.208 | 12-13/B-A | M/6 | 80
Steel Assembly | RIGID_FRAME | 56.3 | +5.976 | +7.337 | 12-13/C-A | M/19 | 80
Steel Assembly | RIGID_FRAME | 50.3 | +5.003 | +6.151 | 12-13/B-A | M/12 | 80
Steel Assembly | RIGID_FRAME | 50.3 | +4.031 | +5.179 | 12-13/B-A | M/12 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 3-4/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 49.8 | +3.108 | +4.208 | 1-2/B-A | M/6 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 2-3/B-A | M/5 | 80
Steel Assembly | RIGID_FRAME | 56.3 | +5.976 | +7.337 | 1-2/C-A | M/19 | 80
Steel Assembly | RIGID_FRAME | 50.3 | +5.003 | +6.151 | 1-2/B-A | M/12 | 80
Steel Assembly | RIGID_FRAME | 50.3 | +4.031 | +5.179 | 1-2/B-A | M/12 | 80
Steel Assembly | RIGID_FRAME | 72.9 | +5.914 | +6.213 | 1-2/B-A | M/18 | 354.061
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 11-12/B-A | M/7 | 293.171
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 10-11/B-A | M/8 | 293.103
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 9-10/B-A | M/7 | 293.034
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 8-9/B-A | M/8 | 292.965
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 7-8/B-A | M/7 | 292.896
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 6-7/B-A | M/9 | 292.827
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 5-6/B-A | M/9 | 292.759
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 4-5/B-A | M/9 | 292.69
Steel Assembly | RIGID_FRAME | 72.6 | +5.914 | +6.213 | 12-13/B-A | M/17 | 354.061
Steel Assembly | RIGID_FRAME | 72.8 | +4.942 | +5.240 | 12-13/B-A | M/15 | 352.728
Steel Assembly | RIGID_FRAME | 72.8 | +3.970 | +4.268 | 12-13/B-A | M/10 | 351.792
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 3-4/B-A | M/9 | 292.621
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 2-3/B-A | M/9 | 292.552
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 11-12/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 10-11/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 9-10/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 8-9/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 7-8/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 6-7/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 5-6/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 4-5/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 3-4/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 2-3/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 11-12/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 10-11/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 9-10/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 8-9/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 7-8/B-A | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 6-7/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 5-6/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 4-5/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 3-4/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 2-3/B-A | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 63.9 | +7.210 | +7.330 | 12-13/C-B | M/21 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 11-12/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 10-11/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 9-10/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 8-9/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 7-8/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 6-7/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 63.9 | +7.210 | +7.330 | 1-2/C-B | M/21 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 2-3/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 3-4/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 4-5/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 65.1 | +7.210 | +7.330 | 5-6/C-B | M/20 | 120
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 11-12/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 10-11/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 11-12/D-C | M/7 | 293.171
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 10-11/D-C | M/8 | 293.103
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 9-10/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 8-9/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 9-10/D-C | M/7 | 293.034
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 8-9/D-C | M/8 | 292.965
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 7-8/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 6-7/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 7-8/D-C | M/7 | 292.896
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 6-7/D-C | M/9 | 292.827
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 5-6/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 4-5/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 5-6/D-C | M/9 | 292.759
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 4-5/D-C | M/9 | 292.69
Steel Assembly | RIGID_FRAME | 49.8 | +3.108 | +4.208 | 12-13/D-C | M/6 | 80
Steel Assembly | RIGID_FRAME | 56.3 | +5.976 | +7.337 | 12-13/D-B | M/19 | 80
Steel Assembly | RIGID_FRAME | 50.3 | +5.003 | +6.151 | 12-13/D-C | M/12 | 80
Steel Assembly | RIGID_FRAME | 50.3 | +4.031 | +5.179 | 12-13/D-C | M/12 | 80
Steel Assembly | RIGID_FRAME | 72.6 | +5.914 | +6.213 | 12-13/D-C | M/17 | 354.061
Steel Assembly | RIGID_FRAME | 72.8 | +4.942 | +5.240 | 12-13/D-C | M/15 | 352.728
Steel Assembly | RIGID_FRAME | 72.8 | +3.970 | +4.268 | 12-13/D-C | M/10 | 351.792
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 3-4/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 3-4/D-C | M/9 | 292.621
Steel Assembly | RIGID_FRAME | 49.8 | +3.108 | +4.208 | 1-2/D-C | M/6 | 80
Steel Assembly | RIGID_FRAME | 44.4 | +3.104 | +4.209 | 2-3/D-C | M/5 | 80
Steel Assembly | RIGID_FRAME | 72.6 | +3.971 | +4.223 | 2-3/D-C | M/9 | 292.552
Steel Assembly | RIGID_FRAME | 56.3 | +5.976 | +7.337 | 1-2/D-B | M/19 | 80
Steel Assembly | RIGID_FRAME | 72.9 | +5.914 | +6.213 | 1-2/D-C | M/18 | 354.061
Steel Assembly | RIGID_FRAME | 50.3 | +5.003 | +6.151 | 1-2/D-C | M/12 | 80
Steel Assembly | RIGID_FRAME | 72.9 | +4.942 | +5.240 | 1-2/D-C | M/16 | 352.728
Steel Assembly | RIGID_FRAME | 50.3 | +4.031 | +5.179 | 1-2/D-C | M/12 | 80
Steel Assembly | RIGID_FRAME | 72.9 | +3.970 | +4.268 | 1-2/D-C | M/11 | 351.792
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 11-12/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 10-11/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 9-10/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 8-9/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 7-8/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 6-7/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 5-6/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 4-5/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 3-4/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.988 | +6.138 | 2-3/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 6-7/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 11-12/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 10-11/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 9-10/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 8-9/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 7-8/D-C | M/13 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 5-6/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 4-5/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 3-4/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.2 | +5.016 | +5.166 | 2-3/D-C | M/14 | 250.068
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 2-3/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 3-4/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 4-5/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 5-6/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 6-7/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 7-8/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 8-9/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 9-10/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 10-11/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 68.4 | +3.045 | +3.254 | 1-2/A | M/3 | 214.985
Steel Assembly | RIGID_FRAME | 68.4 | +3.045 | +3.254 | 12-13/A | M/3 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 11-12/A | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 11-12/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 10-11/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 9-10/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 8-9/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 7-8/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 6-7/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 5-6/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 4-5/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 3-4/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 68.4 | +3.045 | +3.254 | 12-13/D | M/3 | 214.985
Steel Assembly | RIGID_FRAME | 68.4 | +3.045 | +3.254 | 1-2/D | M/3 | 214.985
Steel Assembly | RIGID_FRAME | 69.6 | +3.045 | +3.254 | 2-3/D | M/4 | 214.985
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 10-11/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 3-4/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.3 | +2.950 | +3.000 | 12-13/A | FV/2 | 150
Steel Assembly | RIGID_FRAME | 23.3 | +2.950 | +3.000 | 1-2/A | FV/2 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 2-3/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 3-4/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 4-5/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 5-6/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 6-7/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 7-8/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 11-12/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 9-10/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 8-9/A | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.3 | +2.950 | +3.000 | 1-2/D | FV/2 | 150
Steel Assembly | RIGID_FRAME | 23.3 | +2.950 | +3.000 | 12-13/D | FV/2 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 11-12/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 10-11/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 9-10/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 8-9/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 7-8/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 6-7/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 2-3/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 4-5/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 365.5 | +2.960 | +5.283 | 1/D-B | RT/17 | 324.98
Steel Assembly | RIGID_FRAME | 365.9 | +2.960 | +5.283 | 1/C-A | RT/16 | 325
2 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 1-2/C | M/1 | 220
5 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 1-2/D-C | M/1 | 220
Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 1-2/D | M/1 | 220
2 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 1-2/B | M/1 | 220
5 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 1-2/B-A | M/1 | 220
Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 1-2/A | M/1 | 220
Steel Assembly | RIGID_FRAME | 34 | +5.870 | +5.950 | 1/D-B | FV/9 | 50
Steel Assembly | RIGID_FRAME | 51 | +4.370 | +4.450 | 1/D-C | FV/6 | 50
Steel Assembly | RIGID_FRAME | 48.4 | +4.370 | +4.450 | 1/D-A | FV/5 | 50
Steel Assembly | RIGID_FRAME | 51 | +4.370 | +4.450 | 1/B-A | FV/7 | 50
Steel Assembly | RIGID_FRAME | 34 | +5.870 | +5.950 | 1/C-A | FV/9 | 50
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 1/C | GUMI/3 | 10
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 1/D | GUMI/2 | 10
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 1/B | GUMI/3 | 10
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 1/A | GUMI/2 | 10
Steel Assembly | RIGID_FRAME | 34 | +5.870 | +5.950 | 13/C-A | FV/9 | 50
Steel Assembly | RIGID_FRAME | 365.5 | +2.960 | +5.283 | 13/C-A | RT/17 | 324.98
Steel Assembly | RIGID_FRAME | 51 | +4.370 | +4.450 | 13/B-A | FV/6 | 50
Steel Assembly | RIGID_FRAME | 365.9 | +2.960 | +5.283 | 13/D-B | RT/16 | 325
Steel Assembly | RIGID_FRAME | 48.4 | +4.370 | +4.450 | 13/D-A | FV/5 | 50
Steel Assembly | RIGID_FRAME | 51 | +4.370 | +4.450 | 13/D-C | FV/7 | 50
Steel Assembly | RIGID_FRAME | 34 | +5.870 | +5.950 | 13/D-B | FV/9 | 50
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 2-3/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 3-4/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 4-5/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 5-6/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 6-7/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 7-8/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 12-13/B | M/1 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 11-12/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 10-11/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 9-10/B | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 8-9/B | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 2-3/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 3-4/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 4-5/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 5-6/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 6-7/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 7-8/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 12-13/B-A | M/1 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 11-12/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 10-11/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 9-10/B-A | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 8-9/B-A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 2-3/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 3-4/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 4-5/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 5-6/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 6-7/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 7-8/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 12-13/A | M/1 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 11-12/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 10-11/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 9-10/A | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 8-9/A | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 12-13/C | M/1 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 11-12/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 10-11/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 9-10/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 8-9/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 7-8/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 6-7/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 2-3/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 3-4/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 4-5/C | M/2 | 220
2 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 5-6/C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 12-13/D-C | M/1 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 11-12/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 10-11/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 9-10/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 8-9/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 7-8/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 6-7/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 2-3/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 3-4/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 4-5/D-C | M/2 | 220
5 x Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 5-6/D-C | M/2 | 220
Steel Assembly | RIGID_FRAME | 41.8 | +2.980 | +3.060 | 12-13/D | M/1 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 11-12/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 10-11/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 9-10/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 8-9/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 7-8/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 6-7/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 2-3/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 3-4/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 4-5/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 42.5 | +2.980 | +3.060 | 5-6/D | M/2 | 220
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 12/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 12/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 12/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 12/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 12/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 12/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 11/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 11/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 11/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 11/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 11/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 11/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 10/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 10/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 10/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 10/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 10/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 10/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 9/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 9/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 9/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 9/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 9/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 9/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 8/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 8/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 8/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 8/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 8/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 8/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 7/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 7/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 7/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 7/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 7/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 7/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 6/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 6/D-B | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 5-6/<D | S/1 | 60
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 6/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 6/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 6/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 6/D | GUMI/1 | 10
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 13/B | GUMI/3 | 10
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 13/A | GUMI/2 | 10
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 13/C | GUMI/3 | 10
Steel Assembly |  | 0.4 | +2.950 | +2.960 | 13/D | GUMI/2 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 2/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 2/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 2/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 2/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 2/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 2/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 3/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 3/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 3/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 3/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 3/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 3/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 4/C-A | RT/13 | 399.98
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 4/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 4/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 4/A | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 4/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 4/D | GUMI/1 | 10
2 x VB_Fal | REINFORCEMENT_UNIT | 33215.1 | -0.700 | +2.950 | 6-7/B-A | VB_FAL/3 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 5/C-A | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 5/B | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 5/A | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 348.5 | +2.960 | +5.283 | 5/D-B | RT/13 | 399.98
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 5/C | GUMI/1 | 10
Steel Assembly |  | 0.6 | +2.950 | +2.960 | 5/D | GUMI/1 | 10
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 5-6/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 23.8 | +2.950 | +3.000 | 5-6/D | FV/1 | 150
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 5-6/D | S/1 | 60
VB_Fal | REINFORCEMENT_UNIT | 59192.4 | -0.700 | +2.950 | 13/D-A | VB_FAL/2 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 33214.9 | -0.700 | +2.950 | 1-2/D-C | VB_FAL/3 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 121910 | -0.700 | +2.950 | 1-13/C | VB_FAL/5 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 121910 | -0.700 | +2.950 | 1-13/B | VB_FAL/5 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 121910 | -0.700 | +2.950 | 1-13/D | VB_FAL/5 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 112040 | -0.700 | +2.950 | 1-13/A | VB_FAL/1 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 70810 | -0.700 | +2.950 | 12-13/D-A | VB_FAL/4 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 33215.1 | -0.700 | +2.950 | 1-2/B-A | VB_FAL/3 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg
VB_Fal | REINFORCEMENT_UNIT | 59192.4 | -0.700 | +2.950 | 1/D-A | VB_FAL/2 | 200 | Tekla Assembly - Cast unit rebar weight: 0 kg

# IfcMechanicalFastener: Bolt assembly (2044)
In: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Bolt hole diameter (mm) | Bolt count | Bolt standard | Bolt Name
104 x Bolt assembly | 12 | 28 | 8.8 | 4 | 126 | SCHEIBE12-126 | 2 | 934 | MUN12-934 | 14 | 2 | 933 | M12*28
364 x Bolt assembly | 12 | 28 | 8.8 | 8 | 126 | SCHEIBE12-126 | 4 | 934 | MUN12-934 | 16 | 4 | 933 | M12*28
616 x Bolt assembly | 12 | 25 | 8.8 | 4 | 126 | SCHEIBE12-126 | 2 | 934 | MUN12-934 | 16 | 2 | 933 | M12*25
96 x Bolt assembly | 20 | 65 | 8.8 | 4 | 125 | SCHEIBE20-125 | 2 | 934 | MUN20-934 | 22 | 2 | 931 | M20*65
10 x Bolt assembly | 16 | 220 | 8.8 | 8 | 126 | SCHEIBE16-126 | 4 | 934 | MUN16-934 | 18 | 4 | 933 | M16*220
12 x Bolt assembly | 20 | 200 | 8.8 | 4 | 126 | SCHEIBE20-126 | 2 | 934 | MUN20-934 | 22 | 2 | 933 | M20*200
56 x Bolt assembly | 20 | 210 | 8.8 | 4 | 126 | SCHEIBE20-126 | 2 | 934 | MUN20-934 | 22 | 2 | 933 | M20*210
44 x Bolt assembly | 20 | 220 | 8.8 | 2 | 126 | SCHEIBE20-126 | 1 | 934 | MUN20-934 | 22 | 1 | 933 | M20*220
8 x Bolt assembly | 20 | 210 | 8.8 | 2 | 126 | SCHEIBE20-126 | 1 | 934 | MUN20-934 | 22 | 1 | 933 | M20*210
24 x Bolt assembly | 10 | 18 | 5.8 | 18 | HILTI_125 | HILTI_SCHEIBE10-125 | 18 | HILTI_934 | HILTI_MU10-934 | 12 | 9 | HSA | HSA M10X83 20/10/
39 x Bolt assembly | 24 | 80 | 8.8 | 12 | 125 | SCHEIBE24-125 | 6 | 934 | MUN24-934 | 26 | 6 | 931 | M24*80
143 x Bolt assembly | 24 | 80 | 8.8 | 8 | 125 | SCHEIBE24-125 | 4 | 934 | MUN24-934 | 26 | 4 | 931 | M24*80
182 x Bolt assembly | 20 | 65 | 8.8 | 8 | 125 | SCHEIBE20-125 | 4 | 934 | MUN20-934 | 22 | 4 | 931 | M20*65
96 x Bolt assembly | 20 | 60 | A4 (SS316) | 2 | HILTI_125 | HILTI_SCHEIBE20-125 | 1 | HILTI_934 | HILTI_MU20-934 | 24 | 1 | HST-R | HST M20X200/60
42 x Bolt assembly | 12 | 110 | 8.8 | 4 | 126 | SCHEIBE12-126 | 2 | 934 | MUN12-934 | 14 | 2 | 933 | M12*110
32 x Bolt assembly | 20 | 140 | 8.8 | 4 | 125 | SCHEIBE20-125 | 2 | 934 | MUN20-934 | 22 | 2 | 931 | M20*140
176 x Bolt assembly | 20 | 150 | 8.8 | 4 | 125 | SCHEIBE20-125 | 2 | 934 | MUN20-934 | 22 | 2 | 931 | M20*150
