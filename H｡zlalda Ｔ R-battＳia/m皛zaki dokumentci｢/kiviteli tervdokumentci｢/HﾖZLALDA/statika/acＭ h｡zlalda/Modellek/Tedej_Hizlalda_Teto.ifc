Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Tedej_Hizlalda_Teto.ifc
Time: 2018-01-22T18:33:50
Author: DESKTOP-9KMC89R\HGwor
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla Structures 21.0 Service Release 1, IFC Export Version: 4.0.0.0 Apr 27 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 3650*200 (11)
In: Undefined
Description: 3650*200; Material: CONCRETE/C25/30
Tekla Common - Bottom elevation: -0.700; Top elevation: +2.950; Phase: 1; Class: 99
Tekla Quantity - Height: 3650 mm; Width: 200 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) = NetWeight (kg) | Volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3)
3 x VB_Fal | 33215.1 | 13.3 | 3.6 | 4.3 | 141.6 | 18200 | VB_FAL/3 | 141.6 | 13.286
2 x VB_Fal | 59192.4 | 23.7 | 7.8 | 4.5 | 264.7 | 38800 | VB_FAL/2 | 264.693 | 23.677
VB_Fal | 33214.9 | 13.3 | 3.6 | 4.3 | 141.6 | 18200 | VB_FAL/3 | 141.6 | 13.286
2 x VB_Fal | 121910 | 48.8 | 13.4 | 4.3 | 515.8 | 66799.9 | VB_FAL/5 | 515.819 | 48.7639
VB_Fal | 121910 | 48.8 | 13.4 | 4.3 | 515.8 | 66799.9 | VB_FAL/5 | 515.819 | 48.764
VB_Fal | 112040 | 44.8 | 13.4 | 4.5 | 490.7 | 66799.9 | VB_FAL/1 | 490.7 | 44.816
VB_Fal | 70810 | 28.3 | 7.8 | 4.3 | 300.2 | 38800 | VB_FAL/4 | 300.22 | 28.324

# IfcBeam: KU120/60*3 (48)
In: Undefined
Description: KU120/60*3; Material: STEEL/S235JRG2
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Height: 120 mm; Width: 60 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
20 x Szelemen | +3.124 | +3.254 | 30.1 | 2.7 | 5595 | S/1 | 5595 | 2.60872 | 0.00392769 | 30.8324
4 x Szelemen | +3.124 | +3.254 | 31.3 | 2.8 | 5825 | S/2 | 5824.99 | 2.71596 | 0.00408914 | 32.0998
4 x Szelemen | +3.322 | +3.452 | 31.3 | 2.8 | 5827.5 | S/3 | 5827.49 | 2.71713 | 0.0040909 | 32.1135
20 x Szelemen | +3.322 | +3.452 | 30.1 | 2.7 | 5595 | S/1 | 5595 | 2.60872 | 0.00392769 | 30.8324

# IfcBeam: L50*150*3 (24)
In: Undefined
Description: L50*150*3; Material: STEEL/S235JRG2
Tekla Common - Bottom elevation: +2.950; Top elevation: +3.000; Phase: 1; Class: 95
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 2 m2; Height: 50 mm; Width: 150 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
20 x Profil | 23.8 | 5120 | FV/1 | 5120.02 | 2.04919 | 0.00302593 | 23.7536
4 x Profil | 23.3 | 5020 | FV/2 | 5020.02 | 2.00919 | 0.00296683 | 23.2896

# IfcBeam: L60*3 (4)
In: Undefined
Description: L60*3; Material: STEEL/S235JRG2
Tekla Common - Bottom elevation: +3.186; Top elevation: +7.561; Phase: 2; Class: 13
Tekla Quantity - Weight: 57.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 5 m2; Height: 60 mm; Width: 60 mm; Length: 20785.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: FV/8
BaseQuantities - Length: 20785.5 mm; OuterSurfaceArea: 4.98921 m2; NetVolume: 0.0072957 m3; NetWeight: 57.2712 kg

# IfcBeam: LV10*160 (52)
In: Undefined
Description: LV10*160; Material: MISCELLANEOUS/Gummi
Tekla Common - Bottom elevation: +2.950; Top elevation: +2.960; Phase: 1; Class: 30
Tekla Quantity - Volume: 0 m3; Net surface area: 0.1 m2; Height: 160 mm; Width: 10 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Gumi-lemez | 0.4 | 0 | 220.5 | 250 | GUMI/3 | 249.991 | 0.0881971 | 0.000399986 | 0.399986
2 x Gumi-lemez | 0.4 | 0 | 219.5 | 285 | GUMI/2 | 284.991 | 0.100097 | 0.000455986 | 0.455986
2 x Gumi-lemez | 0.4 | 0 | 220.5 | 250 | GUMI/3 | 249.989 | 0.0881961 | 0.000399982 | 0.399982
2 x Gumi-lemez | 0.4 | 0 | 219.5 | 285 | GUMI/2 | 284.989 | 0.100096 | 0.000455982 | 0.455982
44 x Gumi-lemez | 0.7 | 0.1 | 217.5 | 400 | GUMI/1 | 399.98 | 0.139193 | 0.000639968 | 0.639968

# IfcBeam: LV3*5360 (4)
In: Undefined
Description: LV3*5360; Material: STEEL/S235JRG2
Tekla Common - Bottom elevation: +3.388; Top elevation: +3.451; Phase: 1; Class: 95
Tekla Quantity - Weight: 12.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 88 m2; Net surface area: 1.1 m2; Height: 5360 mm; Width: 3 mm; Length: 97.8 mm
Pset_BeamCommon - LoadBearing: yes; Reference: FV/4
BaseQuantities - Length: 97.751 mm; OuterSurfaceArea: 1.07881 m2; NetVolume: 0.0015611 m3; NetWeight: 12.2546 kg

# IfcBeam: LV3*5460 (20)
In: Undefined
Description: LV3*5460; Material: STEEL/S235JRG2
Tekla Common - Bottom elevation: +3.388; Top elevation: +3.451; Phase: 1; Class: 95
Tekla Quantity - Weight: 12.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 88 m2; Net surface area: 1.1 m2; Height: 5460 mm; Width: 3 mm; Length: 97.8 mm
Pset_BeamCommon - LoadBearing: yes; Reference: FV/3
BaseQuantities - Length: 97.751 mm; OuterSurfaceArea: 1.09893 m2; NetVolume: 0.00159022 m3; NetWeight: 12.4833 kg

# IfcBeam: Z200/2.0_METAL (336)
In: Undefined
Description: Z200/2.0_METAL; Material: STEEL/S235JRG2
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 128.1 m2; Height: 200 mm; Width: 138 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Szelemen | +3.529 | +3.753 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +3.529 | +3.753 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +3.529 | +3.753 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +3.820 | +4.044 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +3.820 | +4.044 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +3.820 | +4.044 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +4.111 | +4.335 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +4.111 | +4.335 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +4.111 | +4.335 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +4.402 | +4.626 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +4.402 | +4.626 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +4.402 | +4.626 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +4.693 | +4.917 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +4.693 | +4.917 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +4.693 | +4.917 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +4.984 | +5.208 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +4.984 | +5.208 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +4.984 | +5.208 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +5.275 | +5.500 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +5.275 | +5.500 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +5.275 | +5.500 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +5.566 | +5.791 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +5.566 | +5.791 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +5.566 | +5.791 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +5.857 | +6.082 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +5.857 | +6.082 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +5.857 | +6.082 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +6.148 | +6.373 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +6.148 | +6.373 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +6.148 | +6.373 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +6.440 | +6.664 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +6.440 | +6.664 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +6.440 | +6.664 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +6.731 | +6.955 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +6.731 | +6.955 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +6.731 | +6.955 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +7.022 | +7.246 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +7.022 | +7.246 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +7.022 | +7.246 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443
2 x Szelemen | +7.313 | +7.537 | 36.5 | 4.7 | 6430 | S/6 | 4.68249 | 0.00465532 | 36.5443
20 x Szelemen | +7.313 | +7.537 | 38.6 | 5 | 6800 | S/5 | 4.95185 | 0.0049232 | 38.6471
2 x Szelemen | +7.313 | +7.537 | 36.5 | 4.7 | 6430 | S/7 | 4.68249 | 0.00465532 | 36.5443

# IfcBeam: ZáRT100/100/4 (160)
In: Undefined
Description: ZáRT100/100/4; Material: STEEL/S235JRG2
Tekla Common - Class: 5
Tekla Quantity - Volume: 0 m3; Area per tons: 33.2 m2; Height: 100 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Profil | +4.059 | +4.178 | 2 | 64.1 | 0 | 2.1 | 5320 | pm/4 | 5320.01 | 2.1296 | 0.00817153 | 64.1465
2 x Profil | +5.032 | +5.150 | 2 | 64.1 | 0 | 2.1 | 5320 | pm/4 | 5320.01 | 2.1296 | 0.00817153 | 64.1465
4 x Profil | +4.059 | +4.178 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5419.99 | 2.1696 | 0.0083251 | 65.3521
4 x Profil | +4.059 | +4.178 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5420.01 | 2.1696 | 0.00832513 | 65.3523
2 x Profil | +4.059 | +4.178 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5420.01 | 2.1696 | 0.00832514 | 65.3523
2 x Profil | +4.059 | +4.178 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.06 | 2.16562 | 0.00830985 | 65.2323
2 x Profil | +4.059 | +4.178 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.07 | 2.16563 | 0.00830987 | 65.2325
2 x Profil | +4.059 | +4.178 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.08 | 2.16563 | 0.00830988 | 65.2326
2 x Profil | +4.059 | +4.178 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.09 | 2.16564 | 0.0083099 | 65.2327
2 x Profil | +4.059 | +4.178 | 2 | 65.2 | 0 | 2.2 | 5410 | pm/2 | 5410.02 | 2.16561 | 0.00830979 | 65.2318
2 x Profil | +4.059 | +4.178 | 2 | 64 | 0 | 2.1 | 5310.1 | pm/1 | 5310.11 | 2.12564 | 0.00815633 | 64.0272
4 x Profil | +6.004 | +6.122 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5419.99 | 2.1696 | 0.0083251 | 65.3521
4 x Profil | +6.004 | +6.122 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5420.01 | 2.1696 | 0.00832513 | 65.3523
2 x Profil | +6.004 | +6.122 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5420.01 | 2.1696 | 0.00832514 | 65.3523
2 x Profil | +6.004 | +6.122 | 2 | 64.1 | 0 | 2.1 | 5320 | pm/4 | 5320.01 | 2.1296 | 0.00817153 | 64.1465
2 x Profil | +6.004 | +6.122 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.06 | 2.16562 | 0.00830985 | 65.2323
2 x Profil | +6.004 | +6.122 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.07 | 2.16563 | 0.00830987 | 65.2325
2 x Profil | +6.004 | +6.122 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.08 | 2.16563 | 0.00830988 | 65.2326
2 x Profil | +6.004 | +6.122 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.09 | 2.16564 | 0.0083099 | 65.2327
2 x Profil | +6.004 | +6.122 | 2 | 65.2 | 0 | 2.2 | 5410 | pm/2 | 5410.02 | 2.16561 | 0.00830979 | 65.2318
2 x Profil | +6.004 | +6.122 | 2 | 64 | 0 | 2.1 | 5310.1 | pm/1 | 5310.11 | 2.12564 | 0.00815633 | 64.0272
4 x Profil | +5.032 | +5.150 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5419.99 | 2.1696 | 0.0083251 | 65.3521
4 x Profil | +5.032 | +5.150 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5420.01 | 2.1696 | 0.00832513 | 65.3523
2 x Profil | +5.032 | +5.150 | 2 | 65.4 | 0 | 2.2 | 5420 | pm/3 | 5420.01 | 2.1696 | 0.00832514 | 65.3523
2 x Profil | +5.032 | +5.150 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.06 | 2.16562 | 0.00830985 | 65.2323
2 x Profil | +5.032 | +5.150 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.07 | 2.16563 | 0.00830987 | 65.2325
2 x Profil | +5.032 | +5.150 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.08 | 2.16563 | 0.00830988 | 65.2326
2 x Profil | +5.032 | +5.150 | 2 | 65.2 | 0 | 2.2 | 5410.1 | pm/2 | 5410.09 | 2.16564 | 0.0083099 | 65.2327
2 x Profil | +5.032 | +5.150 | 2 | 65.2 | 0 | 2.2 | 5410 | pm/2 | 5410.02 | 2.16561 | 0.00830979 | 65.2318
2 x Profil | +5.032 | +5.150 | 2 | 64 | 0 | 2.1 | 5310.1 | pm/1 | 5310.11 | 2.12564 | 0.00815633 | 64.0272
10 x Profil | +7.220 | +7.320 | 2 | 61.1 | 0.5 | 2 | 5070 | pm/5 | 5070.01 | 2.0296 | 0.00778753 | 61.1321
2 x Profil | +7.220 | +7.320 | 2 | 59.9 | 0.5 | 2 | 4970 | pm/6 | 4970.01 | 1.9896 | 0.00763393 | 59.9263
20 x Profil | +3.119 | +3.237 | 1 | 65.2 | 0 | 2.2 | 5410 | pm/2 | 5409.99 | 2.1656 | 0.00830975 | 65.2315
4 x Profil | +3.119 | +3.237 | 1 | 64 | 0 | 2.1 | 5310 | pm/1 | 5309.99 | 2.1256 | 0.00815615 | 64.0258
26 x Profil | +2.980 | +3.080 | 2 | 120.2 | 1 | 4 | 9970 | prt/28 | 9969.97 | 3.98959 | 0.0153139 | 120.214
26 x Profil | +2.980 | +3.080 | 2 | 110.9 | 1 | 3.7 | 9199.7 | prt/27 | 9199.7 | 3.68148 | 0.0141307 | 110.926

# IfcBeam: ZáRT160/160/5 (26)
In: Undefined
Description: ZáRT160/160/5; Material: STEEL/S235JRG2
Tekla Common - Bottom elevation: +4.755; Top elevation: +7.347; Phase: 2; Class: 6
Tekla Quantity - Weight: 284.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.3 m2; Net surface area: 7.5 m2; Height: 160 mm; Width: 160 mm; Length: 11714.4 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 11714.4 mm; OuterSurfaceArea: 7.48959 m2; NetVolume: 0.036262 m3; NetWeight: 284.657 kg
Name | Reference
10 x Profil | prt/3
16 x Profil | prt/4

# IfcBeam: ZáRT80/50/3 (10)
In: Undefined
Description: ZáRT80/50/3; Material: STEEL/S235JRG2
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.3 m2; Area per tons: 44.1 m2; Height: 80 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x Profil | +5.870 | +5.950 | 34 | 1.5 | 5818.3 | FV/9 | 5818.33 | 1.49994 | 0.00432884 | 33.9814
2 x Profil | +4.370 | +4.450 | 51 | 2.2 | 8725.8 | FV/6 | 8725.8 | 2.24908 | 0.006492 | 50.9622
2 x Profil | +4.370 | +4.450 | 48.4 | 2.1 | 8289.7 | FV/5 | 8289.68 | 2.13671 | 0.00616752 | 48.415
2 x Profil | +4.370 | +4.450 | 51 | 2.2 | 8725.8 | FV/7 | 8725.8 | 2.24908 | 0.006492 | 50.9622

# IfcBeam: ZáRT80/60/3 (20)
In: Undefined
Description: ZáRT80/60/3; Material: STEEL/S235JRG2
Tekla Common - Bottom elevation: +3.181; Top elevation: +4.133; Phase: 2; Class: 8
Tekla Quantity - Weight: 41.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.1 m2; Net surface area: 1.8 m2; Height: 80 mm; Width: 60 mm; Length: 6570.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: pm/22
BaseQuantities - Length: 6570.15 mm; OuterSurfaceArea: 1.83024 m2; NetVolume: 0.0052824 m3; NetWeight: 41.4669 kg

# IfcBeam: ZáRT80/80/3 (208)
In: Undefined
Description: ZáRT80/80/3; Material: STEEL/S235JRG2
Tekla Common - Phase: 2; Class: 3
Tekla Quantity - Volume: 0 m3; Area per tons: 44.1 m2; Height: 80 mm; Width: 80 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x Profil | +6.051 | +7.263 | 53.4 | 0 | 2.4 | 7368.8 | pm/17 | 7368.77 | 2.35897 | 0.00680875 | 53.4487
4 x Profil | +5.078 | +6.077 | 47.4 | 0 | 2.1 | 6534.5 | pm/18 | 6534.53 | 2.09201 | 0.0060379 | 47.3975
4 x Profil | +4.105 | +5.104 | 47.4 | 0 | 2.1 | 6534.5 | pm/18 | 6534.37 | 2.09196 | 0.00603776 | 47.3964
4 x Profil | +3.183 | +4.133 | 46.9 | 0 | 2.1 | 6466.5 | pm/19 | 6466.48 | 2.07023 | 0.00597503 | 46.904
32 x Profil | +2.980 | +3.060 | 39 | 0.3 | 1.8 | 5380 | pm/20 | 5380 | 1.72256 | 0.00497112 | 39.0233
160 x Profil | +2.980 | +3.060 | 39.7 | 0.3 | 1.8 | 5480 | pm/21 | 5480 | 1.75456 | 0.00506352 | 39.7486

# IfcDiscreteAccessory: Lemez (2256)
In: Undefined
Material: STEEL/S235JRG2
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
24 x Lemez | PL10*80 | +3.970 | +4.209 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
20 x Lemez | PL10*80 | +3.971 | +4.211 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
20 x Lemez | PL10*80 | +3.104 | +3.343 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
20 x Lemez | PL10*80 | +3.103 | +3.342 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | prt/52 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +3.108 | +3.347 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +3.107 | +3.346 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | prt/52 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +7.100 | +7.337 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +7.101 | +7.339 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | prt/52 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +5.976 | +6.214 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +5.975 | +6.213 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +5.913 | +6.151 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +5.914 | +6.153 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +5.003 | +5.241 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +5.001 | +5.240 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +4.940 | +5.179 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +4.942 | +5.181 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +4.031 | +4.269 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +4.029 | +4.268 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x Lemez | PL10*80 | +3.968 | +4.208 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 80 | 10 | 230 | pm/12 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
20 x Lemez | PL10*250 | +4.014 | +4.223 | 2 | 99 | 3.1 | 0 | 28.1 | 0.1 | 250 | 10 | 160 | pm/10 | 0.0882 | 0.0882 | 0.0025 | 0.0004 | 0.0004
28 x Lemez | PL10*250 | +4.044 | +4.194 | 2 | 99 | 2 | 0 | 29 | 0.1 | 250 | 10 | 100 | pm/11 | 0.057 | 0.057 | 0.0025 | 0.00025 | 0.00025
48 x Lemez | PL10*250 | +5.988 | +6.138 | 2 | 99 | 2 | 0 | 29 | 0.1 | 250 | 10 | 100 | pm/11 | 0.057 | 0.057 | 0.0025 | 0.00025 | 0.00025
48 x Lemez | PL10*250 | +5.016 | +5.166 | 2 | 99 | 2 | 0 | 29 | 0.1 | 250 | 10 | 100 | pm/11 | 0.057 | 0.057 | 0.0025 | 0.00025 | 0.00025
48 x Lemez | PL10*90 | +7.210 | +7.330 | 2 | 99 | 0.7 | 0 | 30.4 | 0 | 90 | 10 | 120 | prt/53 | 0.0258 | 0.0108 | 0.0001 | 0.000108 | 0.000108
24 x Lemez | PL10*120 | +7.210 | +7.330 | 2 | 99 | 1.1 | 0 | 29.8 | 0 | 120 | 10 | 120 | pm/9 | 0.0336 | 0.0336 | 0.0012 | 0.000144 | 0.000144
24 x Lemez | PL10*90 | +7.210 | +7.330 | 2 | 99 | 0.7 | 0 | 30.3 | 0 | 90 | 10 | 120 | pm/8 | 0.0254828 | 0.0108 | 0.0001 | 0.000107 | 0.000107
48 x Lemez | PL10*190 | +3.045 | +3.254 | 1 | 20 | 2.2 | 0 | 29 | 0.1 | 190.3 | 10 | 215 | pm/7 | 0.0627827 | 0.040911 | 0.0001 | 0.000276841 | 0.000276841
26 x Lemez | LV20*310 | +4.696 | +4.965 | 2 | 99 | 13.2 | 0 | 14.5 | 0.2 | 310 | 20 | 270.9 | prt/56 | 0.191189 | 0.191189 | 0.0062 | 0.00167953 | 0.00167953
26 x Lemez | LV20*310 | +4.692 | +4.961 | 2 | 99 | 13.2 | 0 | 14.5 | 0.2 | 310 | 20 | 270.9 | prt/56 | 0.191189 | 0.191189 | 0.0062 | 0.00167953 | 0.00167953
26 x Lemez | PL15*160 | +5.177 | +5.297 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL15*160 | +5.163 | +5.283 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL15*160 | +5.171 | +5.275 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL15*160 | +5.185 | +5.289 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL15*160 | +4.773 | +4.877 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL15*160 | +4.787 | +4.891 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL15*160 | +5.071 | +5.142 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL15*160 | +5.086 | +5.157 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 160 | 15 | 250 | prt/55 | 0.0923 | 0.0923 | 0.0024 | 0.0006 | 0.0006
26 x Lemez | PL10*130 | +3.395 | +3.524 | 2 | 99 | 2.3 | 0 | 28.5 | 0.1 | 130 | 10 | 230 | prt/50 | 0.067 | 0.067 | 0.0013 | 0.000299 | 0.000299
26 x Lemez | PL10*130 | +3.386 | +3.516 | 2 | 99 | 2.3 | 0 | 28.5 | 0.1 | 130 | 10 | 230 | prt/50 | 0.067 | 0.067 | 0.0013 | 0.000299 | 0.000299
26 x Lemez | PL10*130 | +4.929 | +5.059 | 2 | 99 | 2.3 | 0 | 28.5 | 0.1 | 130 | 10 | 230 | prt/50 | 0.067 | 0.067 | 0.0013 | 0.000299 | 0.000299
26 x Lemez | PL10*130 | +4.921 | +5.050 | 2 | 99 | 2.3 | 0 | 28.5 | 0.1 | 130 | 10 | 230 | prt/50 | 0.067 | 0.067 | 0.0013 | 0.000299 | 0.000299
26 x Lemez | PL10*130 | +3.732 | +3.839 | 2 | 99 | 2.3 | 0 | 28.5 | 0.1 | 130 | 10 | 230 | prt/50 | 0.067 | 0.067 | 0.0013 | 0.000299 | 0.000299
26 x Lemez | PL10*130 | +3.741 | +3.848 | 2 | 99 | 2.3 | 0 | 28.5 | 0.1 | 130 | 10 | 230 | prt/50 | 0.067 | 0.067 | 0.0013 | 0.000299 | 0.000299
26 x Lemez | PL10*130 | +3.519 | +3.529 | 2 | 99 | 2.1 | 0 | 28.7 | 0.1 | 130 | 10 | 210 | prt/51 | 0.0614 | 0.0614 | 0.0013 | 0.000273 | 0.000273
26 x Lemez | PL10*130 | +3.529 | +3.539 | 2 | 99 | 2.1 | 0 | 28.7 | 0.1 | 130 | 10 | 210 | prt/51 | 0.0614 | 0.0614 | 0.0013 | 0.000273 | 0.000273
52 x Lemez | PL10*130 | +5.220 | +5.230 | 2 | 99 | 2.1 | 0 | 28.7 | 0.1 | 130 | 10 | 210 | prt/51 | 0.0614 | 0.0614 | 0.0013 | 0.000273 | 0.000273
52 x Lemez | PL10*130 | +5.230 | +5.240 | 2 | 99 | 2.1 | 0 | 28.7 | 0.1 | 130 | 10 | 210 | prt/51 | 0.0614 | 0.0614 | 0.0013 | 0.000273 | 0.000273
26 x Lemez | PL10*130 | +4.338 | +4.348 | 2 | 99 | 2.1 | 0 | 28.7 | 0.1 | 130 | 10 | 210 | prt/51 | 0.0614 | 0.0614 | 0.0013 | 0.000273 | 0.000273
26 x Lemez | PL10*130 | +4.348 | +4.358 | 2 | 99 | 2.1 | 0 | 28.7 | 0.1 | 130 | 10 | 210 | prt/51 | 0.0614 | 0.0614 | 0.0013 | 0.000273 | 0.000273
192 x Lemez | LV10*100 | +2.980 | +3.080 | 2 | 1 | 0.7 | 0 | 30.3 | 0 | 100 | 10 | 120 | prt/15 | 0.0254082 | 0.012 | 0.0001 | 0.000106875 | 0.000106875
2 x Lemez | LV2*160 | +2.968 | +2.970 | 2 | 251 | 0.7 | 0 | 130.7 | 0.1 | 159.7 | 2 | 250 | prt/26 | 0.0779003 | 0.0399244 | 0.000004 | 0.0000759127 | 0.000119888
2 x Lemez | LV3*160 | +2.965 | +2.968 | 2 | 251 | 0.9 | 0 | 88.3 | 0.1 | 159.7 | 3 | 250 | prt/23 | 0.0788941 | 0.0399244 | 0.000009 | 0.000113869 | 0.000179832
2 x Lemez | LV10*160 | +2.960 | +2.970 | 2 | 251 | 3 | 0 | 28.7 | 0.1 | 159.7 | 10 | 250 | prt/17 | 0.0858507 | 0.0399244 | 0.0001 | 0.000379563 | 0.000599438
2 x Lemez | PL5*160 | +2.960 | +2.965 | 2 | 251 | 1.4 | 0 | 54.3 | 0.1 | 159.7 | 5 | 250 | prt/20 | 0.0808817 | 0.0399244 | 0.000025 | 0.000189782 | 0.000299719
2 x Lemez | LV10*160 | +2.970 | +2.980 | 2 | 21 | 3.1 | 0 | 28.1 | 0.1 | 160 | 10 | 250 | prt/14 | 0.0881947 | 0.139193 | 0.0016 | 0.000399975 | 0.000639968
78 x Lemez | PL15*250 | +2.972 | +3.127 | 2 | 99 | 4.7 | 0 | 19.6 | 0.1 | 250 | 15 | 155 | prt/54 | 0.08965 | 0.08965 | 0.00375 | 0.00058125 | 0.00058125
26 x Lemez | LV5*140 | +3.099 | +3.400 | 2 | 7 | 7.8 | 0 | 53 | 0.4 | 140 | 5 | 1426.4 | prt/39 | 0.415051 | 0.415051 | 0.0007 | 0.000998467 | 0.000998467
26 x Lemez | LV5*140 | +2.980 | +3.099 | 2 | 7 | 0.7 | 0 | 54.9 | 0 | 140 | 5 | 118.6 | prt/38 | 0.0357814 | 0.0357814 | 0.0007 | 0.0000829896 | 0.0000829896
26 x Lemez | LV5*140 | +2.980 | +3.232 | 2 | 7 | 1.4 | 0 | 53.8 | 0.1 | 140 | 5 | 252.1 | prt/37 | 0.0745223 | 0.0745223 | 0.0007 | 0.000176502 | 0.000176502
26 x Lemez | LV5*140 | +3.232 | +3.532 | 2 | 7 | 7.8 | 0 | 53 | 0.4 | 140 | 5 | 1417 | prt/36 | 0.412323 | 0.412323 | 0.0007 | 0.000991884 | 0.000991884
52 x Lemez | LV5*263 | +2.985 | +3.547 | 2 | 7 | 9.2 | 0 | 53 | 0.4 | 263 | 5 | 1601.6 | prt/29 | 0.48796 | 0.421157 | 0.000025 | 0.00117451 | 0.00117451
26 x Lemez | LV20*310 | +7.131 | +7.402 | 2 | 99 | 13.2 | 0 | 14.5 | 0.2 | 310 | 20 | 270.9 | prt/56 | 0.191189 | 0.191189 | 0.0062 | 0.00167953 | 0.00167953
2 x Lemez | LV2*160 | +2.968 | +2.970 | 2 | 251 | 0.7 | 0 | 130.5 | 0.1 | 159.7 | 2 | 285 | prt/25 | 0.0892198 | 0.0455142 | 0.000004 | 0.0000870922 | 0.000119888
2 x Lemez | LV3*160 | +2.965 | +2.968 | 2 | 251 | 0.9 | 0 | 88 | 0.1 | 159.7 | 3 | 285 | prt/22 | 0.0902836 | 0.0455142 | 0.000009 | 0.000130638 | 0.000179832
2 x Lemez | LV10*160 | +2.960 | +2.970 | 2 | 251 | 3.4 | 0 | 28.6 | 0.1 | 159.7 | 10 | 285 | prt/16 | 0.0977302 | 0.0455142 | 0.0001 | 0.000435461 | 0.000599438
2 x Lemez | PL5*160 | +2.960 | +2.965 | 2 | 251 | 1.7 | 0 | 54.1 | 0.1 | 159.7 | 5 | 285 | prt/19 | 0.0924112 | 0.0455142 | 0.000025 | 0.00021773 | 0.000299719
2 x Lemez | LV10*160 | +2.970 | +2.980 | 2 | 21 | 3.6 | 0 | 28 | 0.1 | 160 | 10 | 285 | prt/13 | 0.100095 | 0.139193 | 0.0016 | 0.000455975 | 0.000639968
26 x Lemez | LV5*80 | +3.272 | +3.352 | 2 | 3 | 0.4 | 0 | 57.3 | 0 | 80 | 5 | 80 | prt/33 | 0.0144 | 0.0144 | 0.0004 | 0.000032 | 0.000032
26 x Lemez | LV5*73 | +3.338 | +3.454 | 2 | 1 | 0.4 | 0 | 57.5 | 0 | 73.4 | 5 | 115 | prt/32 | 0.0147776 | 0.00843706 | 0.000025 | 0.0000327198 | 0.0000327198
26 x Lemez | LV5*90 | +3.334 | +3.448 | 2 | 3 | 0.4 | 0 | 56 | 0 | 90 | 5 | 115 | prt/31 | 0.02275 | 0.02275 | 0.00045 | 0.00005175 | 0.00005175
26 x Lemez | LV5*90 | +3.029 | +3.232 | 2 | 3 | 0.7 | 0 | 54.9 | 0 | 90 | 5 | 206 | prt/30 | 0.0400466 | 0.0400466 | 0.00045 | 0.0000927156 | 0.0000927156
2 x Lemez | LV2*160 | +2.968 | +2.970 | 2 | 251 | 0.7 | 0 | 130.7 | 0.1 | 159.7 | 2 | 250 | prt/26 | 0.0779042 | 0.0399263 | 0.000004 | 0.0000759166 | 0.000119888
2 x Lemez | LV3*160 | +2.965 | +2.968 | 2 | 251 | 0.9 | 0 | 88.3 | 0.1 | 159.7 | 3 | 250 | prt/23 | 0.078898 | 0.0399263 | 0.000009 | 0.000113875 | 0.000179832
2 x Lemez | LV10*160 | +2.960 | +2.970 | 2 | 251 | 3 | 0 | 28.7 | 0.1 | 159.7 | 10 | 250 | prt/17 | 0.0858547 | 0.0399263 | 0.0001 | 0.000379583 | 0.000599438
2 x Lemez | PL5*160 | +2.960 | +2.965 | 2 | 251 | 1.4 | 0 | 54.3 | 0.1 | 159.7 | 5 | 250 | prt/20 | 0.0808856 | 0.0399263 | 0.000025 | 0.000189791 | 0.000299719
2 x Lemez | LV10*160 | +2.970 | +2.980 | 2 | 21 | 3.1 | 0 | 28.1 | 0.1 | 160 | 10 | 250 | prt/14 | 0.0881985 | 0.139193 | 0.0016 | 0.000399993 | 0.000639968
2 x Lemez | LV2*160 | +2.968 | +2.970 | 2 | 251 | 0.7 | 0 | 130.5 | 0.1 | 159.7 | 2 | 285 | prt/25 | 0.0892237 | 0.045516 | 0.000004 | 0.0000870961 | 0.000119888
2 x Lemez | LV3*160 | +2.965 | +2.968 | 2 | 251 | 0.9 | 0 | 88 | 0.1 | 159.7 | 3 | 285 | prt/22 | 0.0902875 | 0.045516 | 0.000009 | 0.000130644 | 0.000179832
2 x Lemez | LV10*160 | +2.960 | +2.970 | 2 | 251 | 3.4 | 0 | 28.6 | 0.1 | 159.7 | 10 | 285 | prt/16 | 0.0977342 | 0.045516 | 0.0001 | 0.000435481 | 0.000599438
2 x Lemez | PL5*160 | +2.960 | +2.965 | 2 | 251 | 1.7 | 0 | 54.1 | 0.1 | 159.7 | 5 | 285 | prt/19 | 0.0924152 | 0.045516 | 0.000025 | 0.00021774 | 0.000299719
2 x Lemez | LV10*160 | +2.970 | +2.980 | 2 | 21 | 3.6 | 0 | 28 | 0.1 | 160 | 10 | 285 | prt/13 | 0.100098 | 0.139193 | 0.0016 | 0.000455993 | 0.000639968
384 x Lemez | PL10*220 | +2.980 | +3.060 | 2 | 99 | 1.4 | 0 | 29.8 | 0 | 220 | 10 | 80 | pm/13 | 0.0412 | 0.0412 | 0.0022 | 0.000176 | 0.000176
44 x Lemez | LV2*160 | +2.968 | +2.970 | 2 | 251 | 0.9 | 0.1 | 130.5 | 0.1 | 159.7 | 2 | 400 | prt/24 | 0.122824 | 0.0638799 | 0.000004 | 0.000119888 | 0.000119888
44 x Lemez | LV3*160 | +2.965 | +2.968 | 2 | 251 | 1.4 | 0.1 | 88 | 0.1 | 159.7 | 3 | 400 | prt/21 | 0.124292 | 0.0638799 | 0.000009 | 0.000179832 | 0.000179832
44 x Lemez | LV10*160 | +2.960 | +2.970 | 2 | 251 | 4.7 | 0.1 | 28.6 | 0.1 | 159.7 | 10 | 400 | prt/12 | 0.13457 | 0.0638799 | 0.0001 | 0.000599438 | 0.000599438
44 x Lemez | PL5*160 | +2.960 | +2.965 | 2 | 251 | 2.4 | 0.1 | 54.1 | 0.1 | 159.7 | 5 | 400 | prt/18 | 0.127229 | 0.0638799 | 0.000025 | 0.000299719 | 0.000299719
44 x Lemez | LV10*160 | +2.970 | +2.980 | 2 | 21 | 5 | 0.1 | 27.7 | 0.1 | 160 | 10 | 400 | prt/11 | 0.139193 | 0.139193 | 0.0016 | 0.000639968 | 0.000639968

# IfcDiscreteAccessory: Profil (1028)
In: Undefined
Material: STEEL/S235JRG2
Tekla Common - Phase: 2
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
4 x Profil | ZáRT80/80/3 | +5.062 | +5.165 | 3 | 0.9 | 0 | 45.3 | 0 | 80 | 80 | 179 | pm/15 | 0.0442394 | 0.0442394 | 0.00089866 | 0.000124283 | 0.000124283
20 x Profil | ZáRT80/60/3 | +3.160 | +3.266 | 8 | 0.7 | 0 | 45.4 | 0 | 80 | 60 | 139 | prt/85 | 0.0328446 | 0.0328446 | 0.00077866 | 0.0000920751 | 0.0000920751
20 x Profil | ZáRT80/60/3 | +4.048 | +4.147 | 8 | 0.7 | 0 | 45.4 | 0 | 80 | 60 | 163.4 | pm/23 | 0.036357 | 0.036357 | 0.00077866 | 0.000101869 | 0.000101869
4 x Profil | ZáRT80/80/3 | +7.176 | +7.292 | 3 | 0.9 | 0 | 45.3 | 0 | 80 | 80 | 176 | prt/67 | 0.0437471 | 0.0437471 | 0.00089866 | 0.000122899 | 0.000122899
4 x Profil | ZáRT80/80/3 | +5.017 | +5.120 | 3 | 0.9 | 0 | 45.3 | 0 | 80 | 80 | 179 | pm/15 | 0.0442285 | 0.0442285 | 0.00089866 | 0.000124251 | 0.000124251
4 x Profil | ZáRT80/80/3 | +3.159 | +3.271 | 3 | 0.9 | 0 | 45.4 | 0 | 80 | 80 | 156.5 | prt/68 | 0.0405379 | 0.0405379 | 0.00089866 | 0.000113865 | 0.000113865
4 x Profil | ZáRT80/80/3 | +6.034 | +6.138 | 3 | 0.9 | 0 | 45.3 | 0 | 80 | 80 | 164.4 | pm/14 | 0.0418405 | 0.0418405 | 0.00089866 | 0.000117536 | 0.000117536
4 x Profil | ZáRT80/80/3 | +5.989 | +6.092 | 3 | 0.9 | 0 | 45.3 | 0 | 80 | 80 | 179 | pm/15 | 0.0442292 | 0.0442292 | 0.00089866 | 0.000124253 | 0.000124253
4 x Profil | ZáRT80/80/3 | +4.044 | +4.147 | 3 | 0.9 | 0 | 45.3 | 0 | 80 | 80 | 186.3 | pm/16 | 0.0454385 | 0.0454385 | 0.00089866 | 0.000127649 | 0.000127649
4 x Profil | ZáRT80/80/3 | +4.090 | +4.193 | 3 | 0.9 | 0 | 45.3 | 0 | 80 | 80 | 179 | pm/15 | 0.0442285 | 0.0442285 | 0.00089866 | 0.000124251 | 0.000124251
16 x Profil | L60*3 | +5.810 | +5.870 | 13 | 0.4 | 0 | 88.9 | 0 | 60 | 60 | 140 | prt/60 | 0.034302 | 0.034302 | 0.000355751 | 0.00004914 | 0.00004914
8 x Profil | L60*3 | +4.310 | +4.370 | 13 | 0.4 | 0 | 88.9 | 0 | 60 | 60 | 140 | prt/62 | 0.034302 | 0.034302 | 0.000355751 | 0.00004914 | 0.00004914
4 x Profil | L70*3 | +4.300 | +4.370 | 13 | 0.4 | 0 | 88.6 | 0 | 70 | 70 | 140 | prt/61 | 0.040022 | 0.040022 | 0.000415751 | 0.00005754 | 0.00005754
14 x Profil | L60*3 | +4.310 | +4.370 | 13 | 0.4 | 0 | 88.9 | 0 | 60 | 60 | 140 | prt/60 | 0.034302 | 0.034302 | 0.000355751 | 0.00004914 | 0.00004914
4 x Profil | L50*3 | +2.980 | +3.030 | 13 | 22.5 | 0 | 87.6 | 2 | 50 | 50 | 9850 | prt/58 | 1.97058 | 1.97058 | 0.000295751 | 0.00286634 | 0.00286634
4 x Profil | L50*3 | +2.980 | +3.030 | 13 | 20.9 | 0 | 87.6 | 1.8 | 50 | 50 | 9139.7 | prt/59 | 1.82852 | 1.82852 | 0.000295751 | 0.00265965 | 0.00265965
48 x Profil | L30*3 | +3.030 | +3.060 | 9 | 1.1 | 0 | 84.9 | 0.1 | 30 | 30 | 833.1 | prt/57 | 0.0966339 | 0.0966339 | 0.000174 | 0.000142452 | 0.000144951
26 x Profil | ZáRT80/60/3 | +3.443 | +5.332 | 8 | 13.8 | 0 | 44.2 | 0.6 | 80 | 60 | 2221.9 | prt/69 | 0.609008 | 0.609008 | 0.00077866 | 0.00175564 | 0.00175564
26 x Profil | ZáRT80/60/3 | +3.539 | +5.016 | 2 | 9.2 | 0 | 44.2 | 0.4 | 80 | 60 | 1476.1 | prt/70 | 0.410088 | 0.410088 | 0.00077866 | 0.00118169 | 0.00118169
26 x Profil | ZáRT80/80/3 | +4.977 | +5.352 | 3 | 3 | 0 | 44.5 | 0.1 | 80 | 80 | 419.4 | prt/66 | 0.130593 | 0.130593 | 0.00089866 | 0.000374228 | 0.000374228
26 x Profil | ZáRT80/80/3 | +3.080 | +5.002 | 3 | 16.2 | 0 | 44.2 | 0.6 | 80 | 80 | 2260.3 | prt/65 | 0.716422 | 0.716422 | 0.00089866 | 0.00206565 | 0.00206565
26 x Profil | ZáRT80/60/3 | +5.240 | +5.664 | 2 | 2.6 | 0 | 44.5 | 0.1 | 80 | 60 | 423.8 | prt/71 | 0.117081 | 0.117081 | 0.00077866 | 0.000335632 | 0.000335632
26 x Profil | ZáRT80/80/3 | +3.782 | +5.978 | 3 | 17.4 | 0 | 44.2 | 0.8 | 80 | 80 | 2430.1 | prt/64 | 0.76895 | 0.76895 | 0.00089866 | 0.00221721 | 0.00221721
26 x Profil | ZáRT90/90/5 | +5.224 | +6.004 | 4 | 11.1 | 0 | 27.1 | 0.4 | 90 | 90 | 839.6 | prt/49 | 0.30031 | 0.30031 | 0.00162961 | 0.00140952 | 0.00140952
26 x Profil | ZáRT80/60/3 | +4.358 | +6.312 | 2 | 12.3 | 0 | 44.2 | 0.4 | 80 | 60 | 1954.3 | prt/72 | 0.543235 | 0.543235 | 0.00077866 | 0.00156615 | 0.00156615
26 x Profil | ZáRT90/90/5 | +5.228 | +6.629 | 4 | 19.7 | 0 | 27.1 | 0.4 | 90 | 90 | 1502.4 | prt/48 | 0.532246 | 0.566484 | 0.00162961 | 0.00250405 | 0.00266657
26 x Profil | ZáRT90/90/5 | +4.830 | +6.651 | 4 | 25.7 | 0 | 27 | 0.6 | 90 | 90 | 1932.1 | prt/47 | 0.694747 | 0.723907 | 0.00162961 | 0.0032722 | 0.00340995
26 x Profil | ZáRT80/60/3 | +5.240 | +6.960 | 2 | 10.8 | 0 | 44.2 | 0.4 | 80 | 60 | 1720.4 | prt/73 | 0.478095 | 0.520402 | 0.00077866 | 0.00137806 | 0.00150025
26 x Profil | ZáRT90/90/5 | +5.119 | +7.184 | 4 | 28 | 0 | 27 | 0.8 | 90 | 90 | 2119.1 | prt/46 | 0.757219 | 0.7889 | 0.00162961 | 0.00356682 | 0.00371686
26 x Profil | QR80*4 | +3.110 | +3.351 | 3 | 10.3 | 0 | 32.9 | 0.4 | 80 | 80 | 1090.6 | prt/41 | 0.338078 | 0.338078 | 0.0012 | 0.0011584 | 0.00130869
26 x Profil | QR80*4 | +3.030 | +3.110 | 3 | 8.6 | 0.1 | 32.9 | 0.4 | 80 | 80 | 910.1 | prt/40 | 0.282119 | 0.282119 | 0.0012 | 0.0010963 | 0.00109208
7 x Profil | ZáRT160/160/5 | +3.103 | +4.903 | 6 | 194 | 0 | 26.3 | 5.1 | 160 | 160 | 8037.9 | prt/6 | 5.10645 | 5.10645 | 0.00302961 | 0.0247166 | 0.0247166
52 x Profil | ZáRT80/60/3 | +3.080 | +5.220 | 2 | 13.5 | 0 | 44.2 | 0.6 | 80 | 60 | 2140 | prt/74 | 0.5967 | 0.5967 | 0.00077866 | 0.00172056 | 0.00172056
26 x Profil | ZáRT80/60/3 | +3.080 | +4.338 | 2 | 7.8 | 0 | 44.2 | 0.4 | 80 | 60 | 1257.8 | prt/75 | 0.351054 | 0.351054 | 0.00077866 | 0.00101126 | 0.00101126
26 x Profil | ZáRT80/60/3 | +3.080 | +3.519 | 2 | 2.8 | 0 | 44.5 | 0.1 | 80 | 60 | 439.4 | prt/76 | 0.123186 | 0.123186 | 0.00077866 | 0.000353288 | 0.000353288
26 x Profil | ZáRT80/60/3 | +3.080 | +4.367 | 2 | 8.1 | 0 | 44.2 | 0.4 | 80 | 60 | 1287.3 | prt/77 | 0.3575 | 0.3575 | 0.00077866 | 0.00102984 | 0.00102984
26 x Profil | ZáRT80/60/3 | +3.080 | +3.719 | 2 | 4 | 0 | 44.3 | 0.2 | 80 | 60 | 639 | prt/78 | 0.176993 | 0.176993 | 0.00077866 | 0.000508629 | 0.000508629
26 x Profil | ZáRT160/160/5 | +2.980 | +3.232 | 6 | 4.7 | 0 | 27.1 | 0.1 | 160 | 160 | 252.1 | prt/5 | 0.123563 | 0.123563 | 0.00302961 | 0.000580786 | 0.000580786
26 x Profil | ZáRT90/90/5 | +3.080 | +5.110 | 4 | 27.7 | 0 | 27 | 0.6 | 90 | 90 | 2083.1 | prt/45 | 0.747987 | 0.747987 | 0.00162961 | 0.00352355 | 0.00352355
26 x Profil | ZáRT90/90/5 | +3.080 | +4.834 | 4 | 24.9 | 0 | 27.1 | 0.6 | 90 | 90 | 1880.8 | prt/44 | 0.672689 | 0.672689 | 0.00162961 | 0.00316778 | 0.00316778
26 x Profil | ZáRT90/90/5 | +3.080 | +5.232 | 4 | 30.6 | 0 | 27 | 0.8 | 90 | 90 | 2308.4 | prt/43 | 0.826613 | 0.826613 | 0.00162961 | 0.00389464 | 0.00389464
26 x Profil | ZáRT90/90/5 | +3.080 | +5.236 | 4 | 31.5 | 0 | 27 | 0.8 | 90 | 90 | 2381 | prt/42 | 0.851441 | 0.851441 | 0.00162961 | 0.00401175 | 0.00401175
26 x Profil | ZáRT80/80/3 | +3.080 | +3.798 | 3 | 5.6 | 0 | 44.3 | 0.2 | 80 | 80 | 794.6 | prt/63 | 0.24922 | 0.24922 | 0.00089866 | 0.000716704 | 0.000716704
26 x Profil | ZáRT80/60/3 | +3.080 | +3.468 | 8 | 2.7 | 0 | 44.5 | 0.1 | 80 | 60 | 455.9 | prt/79 | 0.120976 | 0.120976 | 0.00077866 | 0.000346694 | 0.000346694
26 x Profil | ZáRT80/60/3 | +3.080 | +4.707 | 8 | 13.5 | 0 | 44.2 | 0.6 | 80 | 60 | 2177.7 | prt/80 | 0.591916 | 0.591916 | 0.00077866 | 0.0017062 | 0.0017062
26 x Profil | ZáRT80/60/3 | +3.080 | +4.681 | 8 | 13.2 | 0 | 44.2 | 0.6 | 80 | 60 | 2167.9 | prt/81 | 0.580976 | 0.580976 | 0.00077866 | 0.00167401 | 0.00167401
26 x Profil | ZáRT80/60/3 | +3.080 | +4.066 | 8 | 10.3 | 0 | 44.2 | 0.4 | 80 | 60 | 1731.7 | prt/82 | 0.458475 | 0.458475 | 0.00077866 | 0.0013202 | 0.0013202
26 x Profil | ZáRT80/60/3 | +3.080 | +4.024 | 8 | 9.8 | 0 | 44.3 | 0.4 | 80 | 60 | 1697.8 | prt/83 | 0.434838 | 0.434838 | 0.00077866 | 0.00125065 | 0.00125065
26 x Profil | ZáRT80/60/3 | +3.080 | +3.441 | 8 | 7.8 | 0 | 44.5 | 0.4 | 80 | 60 | 1450.6 | prt/84 | 0.346878 | 0.346878 | 0.00077866 | 0.000994702 | 0.000994702
9 x Profil | ZáRT160/160/5 | +3.103 | +4.903 | 6 | 194 | 0 | 26.3 | 5.1 | 160 | 160 | 8037.9 | prt/7 | 5.10645 | 5.10645 | 0.00302961 | 0.0247166 | 0.0247166
4 x Profil | ZáRT160/160/5 | +3.103 | +4.903 | 6 | 194 | 0 | 26.3 | 5.1 | 160 | 160 | 8037.9 | prt/2 | 5.10645 | 5.10645 | 0.00302961 | 0.0247166 | 0.0247166
6 x Profil | ZáRT160/160/5 | +3.103 | +4.903 | 6 | 194 | 0 | 26.3 | 5.1 | 160 | 160 | 8037.9 | prt/1 | 5.10645 | 5.10645 | 0.00302961 | 0.0247166 | 0.0247166

# IfcDiscreteAccessory: Szelemen (364)
In: Undefined
Description: KU120/60*3; Material: STEEL/S235JRG2
Tekla Common - Phase: 2; Class: 7
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.1 m2; Height: 120 mm; Width: 60 mm; Length: 175 mm
Pset_PlateCommon - LoadBearing: yes; Reference: prt/86
BaseQuantities - NetArea: 0.0815962 m2; GrossArea: 0.0815962 m2; CrossSectionArea: 0.000685 m2; NetVolume: 0.000122851 m3; GrossVolume: 0.000119876 m3
Name | Bottom elevation | Top elevation
26 x Szelemen | +3.543 | +3.726
26 x Szelemen | +3.834 | +4.017
26 x Szelemen | +4.125 | +4.308
26 x Szelemen | +4.416 | +4.599
26 x Szelemen | +4.707 | +4.890
26 x Szelemen | +4.998 | +5.182
26 x Szelemen | +5.289 | +5.473
26 x Szelemen | +5.580 | +5.764
26 x Szelemen | +5.871 | +6.055
26 x Szelemen | +6.162 | +6.346
26 x Szelemen | +6.453 | +6.637
26 x Szelemen | +6.744 | +6.928
26 x Szelemen | +7.035 | +7.219
26 x Szelemen | +7.326 | +7.510

# IfcElementAssembly (923)
In: Undefined
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 8/D-C | RT/10 | 413.454
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 6/B-A | RT/10 | 413.454
Steel Assembly | RIGID_FRAME | 12.3 | +3.388 | +3.451 | 12-13/A | FV/4 | 48.973
Steel Assembly | RIGID_FRAME | 12.3 | +3.388 | +3.451 | 1-2/A | FV/4 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 2-3/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 3-4/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 4-5/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 5-6/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 6-7/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 7-8/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 11-12/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 10-11/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 9-10/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 8-9/A | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 6-7/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 31.3 | +3.124 | +3.254 | 1-2/A> | S/2 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 2-3/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 3-4/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 4-5/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 5-6/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 7-8/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 31.3 | +3.124 | +3.254 | 12-13/A> | S/2 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 11-12/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 10-11/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 9-10/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 499.7 | +2.960 | +4.961 | 13/B-A | RT/1 | 354.98
Steel Assembly | RIGID_FRAME | 489.7 | +2.960 | +4.961 | 12/B-A | RT/9 | 419.767
Steel Assembly | RIGID_FRAME | 489.7 | +2.960 | +4.961 | 2/B-A | RT/7 | 419.767
Steel Assembly | RIGID_FRAME | 31.3 | +3.322 | +3.452 | 1-2/A | S/3 | 60
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 3/B-A | RT/3 | 399.98
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 4/B-A | RT/5 | 413.454
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 5/B-A | RT/3 | 399.98
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 7/B-A | RT/3 | 399.98
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 8/B-A | RT/10 | 413.454
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 11/B-A | RT/4 | 399.98
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 10/B-A | RT/11 | 413.454
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 9/B-A | RT/4 | 399.98
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 8-9/A> | S/1 | 60
Steel Assembly | RIGID_FRAME | 31.3 | +3.322 | +3.452 | 12-13/A | S/3 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 2-3/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 3-4/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 4-5/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 5-6/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 6-7/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 7-8/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 11-12/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 10-11/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 9-10/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 8-9/A | S/1 | 60
Steel Assembly | RIGID_FRAME | 31.3 | +3.124 | +3.254 | 12-13/<D | S/2 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 7-8/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 11-12/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 10-11/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 9-10/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 8-9/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 6-7/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 31.3 | +3.124 | +3.254 | 1-2/<D | S/2 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 2-3/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 3-4/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 30.1 | +3.124 | +3.254 | 4-5/<D | S/1 | 60
Steel Assembly | RIGID_FRAME | 489.7 | +2.960 | +4.961 | 12/D-C | RT/8 | 419.767
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 11/D-C | RT/4 | 399.98
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 10/D-C | RT/10 | 413.454
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 9/D-C | RT/4 | 399.98
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 7/D-C | RT/3 | 399.98
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 6/D-C | RT/10 | 413.454
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 5/D-C | RT/3 | 399.98
Steel Assembly | RIGID_FRAME | 489.5 | +2.960 | +4.961 | 4/D-C | RT/5 | 413.454
Steel Assembly | RIGID_FRAME | 485.2 | +2.960 | +4.961 | 3/D-C | RT/3 | 399.98
Steel Assembly | RIGID_FRAME | 499.7 | +2.960 | +4.961 | 1/D-C | RT/1 | 354.98
Steel Assembly | RIGID_FRAME | 489.7 | +2.960 | +4.961 | 2/D-C | RT/6 | 419.767
Steel Assembly | RIGID_FRAME | 12.3 | +3.388 | +3.451 | 1-2/D | FV/4 | 48.973
Steel Assembly | RIGID_FRAME | 31.3 | +3.322 | +3.452 | 1-2/D | S/3 | 60
Steel Assembly | RIGID_FRAME | 31.3 | +3.322 | +3.452 | 12-13/D | S/3 | 60
Steel Assembly | RIGID_FRAME | 12.3 | +3.388 | +3.451 | 12-13/D | FV/4 | 48.973
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 11-12/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 11-12/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 10-11/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 10-11/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 9-10/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 9-10/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 8-9/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 8-9/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 7-8/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 7-8/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 6-7/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 6-7/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 2-3/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 2-3/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 3-4/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 3-4/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 12.5 | +3.388 | +3.451 | 4-5/D | FV/3 | 48.973
Steel Assembly | RIGID_FRAME | 30.1 | +3.322 | +3.452 | 4-5/D | S/1 | 60
Steel Assembly | RIGID_FRAME | 57.3 | +3.186 | +7.561 | 13/<D-B | FV/8 | 60
Steel Assembly | RIGID_FRAME | 57.3 | +3.186 | +7.561 | 13/C-A> | FV/8 | 60
Steel Assembly | RIGID_FRAME | 57.3 | +3.186 | +7.561 | 1/C-A> | FV/8 | 60
Steel Assembly | RIGID_FRAME | 57.3 | +3.186 | +7.561 | 1/<D-B | FV/8 | 60
Steel Assembly | RIGID_FRAME | 36.5 | +3.529 | +3.753 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +3.529 | +3.753 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.529 | +3.753 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +3.820 | +4.044 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +3.820 | +4.044 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +3.820 | +4.044 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.111 | +4.335 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.111 | +4.335 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.111 | +4.335 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.402 | +4.626 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.402 | +4.626 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.402 | +4.626 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.693 | +4.917 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.693 | +4.917 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.693 | +4.917 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.984 | +5.208 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +4.984 | +5.208 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +4.984 | +5.208 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.275 | +5.500 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.275 | +5.500 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.275 | +5.500 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.566 | +5.791 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.566 | +5.791 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.566 | +5.791 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.857 | +6.082 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +5.857 | +6.082 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +5.857 | +6.082 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.148 | +6.373 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.148 | +6.373 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.148 | +6.373 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.440 | +6.664 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.440 | +6.664 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.440 | +6.664 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.731 | +6.955 | 1-3/B-A | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 1-4/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 2-5/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 3-6/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 4-7/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 5-8/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 6-9/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +6.731 | +6.955 | 11-13/B-A | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 10-13/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 7-10/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 9-12/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +6.731 | +6.955 | 8-11/B-A | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.022 | +7.246 | 1-3/B | S/6 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 1-4/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 2-5/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 3-6/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 4-7/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 5-8/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 6-9/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.022 | +7.246 | 11-13/B | S/7 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 10-13/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 7-10/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 9-12/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 38.6 | +7.022 | +7.246 | 8-11/B | S/5 | 138
Steel Assembly | RIGID_FRAME | 36.5 | +7.313 | +7.537 | 1-3/C-B | S/6 | 138
